PRINC = "1"

RPROVIDES_${PN} =+ " libgmp10"
