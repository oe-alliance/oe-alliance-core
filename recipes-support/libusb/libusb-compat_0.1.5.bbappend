PRINC = "1"

RPROVIDES_${PN} += " libusb-0.1-4"
