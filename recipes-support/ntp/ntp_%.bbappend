PRINC = "4"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
