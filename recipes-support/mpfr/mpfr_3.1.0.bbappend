PRINC = "1"

RPROVIDES_${PN} =+ " libmpfr4"
