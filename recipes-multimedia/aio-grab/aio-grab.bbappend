PRINC = "1"

SRC_URI="git://github.com/oe-alliance/aio-grab.git;protocol=git"
