require libtheora.inc

PR = "${INC_PR}.0"
 
SRC_URI += "file://no-docs.patch;patch=1"

