PRINC = "1"

SRC_URI += "file://0001-v4l2-fix-build-with-recent-kernels-the-v4l2_buffer-i.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"
