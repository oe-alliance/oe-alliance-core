PRINC = "1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI = "dvbsnoop.tar.gz"
