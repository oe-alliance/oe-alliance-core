require gigablue-buildimage_${PV}.bb
inherit native
