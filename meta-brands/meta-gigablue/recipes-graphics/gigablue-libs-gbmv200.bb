SRCDATE = "20190402"

require gigablue-libs.inc

SRC_URI[md5sum] = "e6d1a6c3c238dbde44d43822dbe7ee49"
SRC_URI[sha256sum] = "4ee836c71d7f4d947962e11dcddc24d7ed8344589741a24e483eb79eb280187d"
