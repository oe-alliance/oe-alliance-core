SRCDATE = "20241211.r0"

require gb-v3ddriver.inc

SRC_URI[md5sum] = "7ae07d4da934847ce6fa457c44fcf1d8"
SRC_URI[sha256sum] = "db06b5229d83c8163cc7eca7ed880bbd6449f0bd0440ff62da04451b6fab4beb"
COMPATIBLE_MACHINE = "gb7252"
