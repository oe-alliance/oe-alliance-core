SRCDATE = "20191015.r0"

require gb-v3ddriver.inc

SRC_URI[md5sum] = "27a19d7d5ea3712f365b08f08291adc0"
SRC_URI[sha256sum] = "3c95f5c3abaddfa679afec4af9f3e002d95aa99b8121cfbcd375ce03fc2e4443"
COMPATIBLE_MACHINE = "gb72604"
