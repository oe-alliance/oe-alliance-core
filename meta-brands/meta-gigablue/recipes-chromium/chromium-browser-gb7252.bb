SRCDATE = "20180807_r0"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(gb7252)$"

SRC_URI[md5sum] = "ccc6d288699ad216cc429f258ccb0610"
SRC_URI[sha256sum] = "5cfd36859025be14310c945e0759f8b8686d3e8e44fe03331477bc05775d729f"
