require bluetoothsetup.inc

COMPATIBLE_MACHINE = "gb7252"

SRCDATE = "20180807"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "a5254bc03277050e3605b5f1869e74a1"
SRC_URI[sha256sum] = "db27b459492b4cbd6354fdc00c141dfacea22a45613e9df958ab88e7944c3357"
