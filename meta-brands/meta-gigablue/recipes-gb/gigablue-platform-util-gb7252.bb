require gigablue-platform-util.inc

SRCDATE = "20170418"

SRC_URI[md5sum] = "6141b82b03beb62fefd1829c025f3a42"
SRC_URI[sha256sum] = "27c0ce7d23fc830d7517bd9f261ecf82e8e89608156e811e31535901ce36c52f"
