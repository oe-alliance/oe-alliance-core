SRCDATE = "20170122"

require gigablue-initrd-cfe.inc

SRC_URI[md5sum] = "b045afe47446fdf9c474e2153987be13"
SRC_URI[sha256sum] = "56c04045cbd5abddbbfa7c0be92e571e61c145e9abe95c5e7836015b741c5b13"
