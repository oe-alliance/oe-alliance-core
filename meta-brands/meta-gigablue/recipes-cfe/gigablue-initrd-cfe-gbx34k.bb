SRCDATE = "20191015r2"

require gigablue-initrd-cfe.inc

SRC_URI[md5sum] = "368fa51a49cb07257732abd355c5ad2a"
SRC_URI[sha256sum] = "6f8bef1c72f699c91719462a7f938cbe45cad6f5b36e137cdccc2f3646ccfd43"
