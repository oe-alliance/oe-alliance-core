SRCDATE = "20140904"

require gigablue-initrd.inc

SRC_URI[md5sum] = "3cd986bd0c1a6f77b8b1860eac7299d0"
SRC_URI[sha256sum] = "6a4484bc326672976869b9c4d743659851bcd80ab6f81bdbca87e6297f242032"
