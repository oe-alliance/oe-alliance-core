SRCDATE = "20181102"

require gigablue-initrd-cfe.inc

SRC_URI[md5sum] = "ab30270f2d7a5b5073d8b50b98643db3"
SRC_URI[sha256sum] = "77683f8dfa3e056bce51aa9a0eca6166320733dde9dd7565fa85a4a029295087"
