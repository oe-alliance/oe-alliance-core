SRCDATE = "20140627"

require gigablue-initrd.inc

SRC_URI[md5sum] = "9b87984788984e0d6ec0388b8b37383c"
SRC_URI[sha256sum] = "e21f82efa530d46f590181f36cc3f3b0f5b2cdeaf53e97309be80fc3a51f8e01"
