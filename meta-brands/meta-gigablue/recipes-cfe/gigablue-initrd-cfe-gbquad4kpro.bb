SRCDATE = "20260426r0"

require gigablue-initrd-cfe.inc

SRC_URI[md5sum] = "813fc29dd9a983afb6788985594c2cf6"
SRC_URI[sha256sum] = "3510e678ee740342ff2ec1fd47c460ff498906056bbfdd1e7aed31242da766e2"
