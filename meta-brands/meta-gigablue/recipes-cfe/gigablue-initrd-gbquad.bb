SRCDATE = "20140430"

require gigablue-initrd.inc

SRC_URI[md5sum] = "1421c9834e93fbdb45e428c80ca3635c"
SRC_URI[sha256sum] = "125fefd0f7217174cda48939a8b4ef88b190b5be1f863e9acae7cf84fbca02da"
