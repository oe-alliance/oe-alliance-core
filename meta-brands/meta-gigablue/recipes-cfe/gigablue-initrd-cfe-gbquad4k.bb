SRCDATE = "20181121r2"

require gigablue-initrd-cfe.inc

SRC_URI[md5sum] = "eb98226d1c880522e3823a1dbd91142b"
SRC_URI[sha256sum] = "010784bf6d1e2ef4d41d835779617d7af63d6d9e86ff4868014b14af14ba215a"
