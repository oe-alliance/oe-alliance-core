SRCDATE = "20140430"

require gigablue-initrd.inc

SRC_URI[md5sum] = "21b26afd4999284181c5d24d189be291"
SRC_URI[sha256sum] = "1ae35df3bba9dd52212c866f8fea637d00e4e06990c3df0d352a130fee806da7"
