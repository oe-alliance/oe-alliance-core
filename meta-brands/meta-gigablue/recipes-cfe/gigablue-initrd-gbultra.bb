SRCDATE = "20141216"

require gigablue-initrd.inc

SRC_URI[md5sum] = "a097509dd373499406b0cce8ba9f3ad9"
SRC_URI[sha256sum] = "066848db11248e2df6f0299308fe43a85223d9381bd4e59d86fb8163aaaeff25"
