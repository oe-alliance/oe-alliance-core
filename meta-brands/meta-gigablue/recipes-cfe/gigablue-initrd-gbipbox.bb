SRCDATE = "20140627"

require gigablue-initrd.inc

SRC_URI[md5sum] = "30dedb031f79da54a6e1d0822e5b6875"
SRC_URI[sha256sum] = "b67a34cf7a717a7b7ac377a4e41a296e30e5cce68b9d23ad892fb648c9c520d8"
