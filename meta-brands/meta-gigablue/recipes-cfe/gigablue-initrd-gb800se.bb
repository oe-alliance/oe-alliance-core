SRCDATE = "20140912"

require gigablue-initrd.inc

SRC_URI[md5sum] = "94ab7cc26d5b525675258f661f7ae7a8"
SRC_URI[sha256sum] = "1a785983ba0cba8130eb6b1d5e47faaaac77c5598318c58b7f379d1ba1fc28f9"
