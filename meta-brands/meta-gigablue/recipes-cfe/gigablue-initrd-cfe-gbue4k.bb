SRCDATE = "20181121r2"

require gigablue-initrd-cfe.inc

SRC_URI[md5sum] = "39e920e3b22c73a5db158cde979b80c2"
SRC_URI[sha256sum] = "826cf76f8d0eb919127e910524e5d3d9aeda78774898c30ee69bdf9e1c8f2e96"
