require gb-bluetooth-util.inc

COMPATIBLE_MACHINE = "gb72604"

SRCDATE = "20260730"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "808a15e970e8e010a1093fe248f73d21"
SRC_URI[sha256sum] = "483a1fb7738232dff7967690cf01c566adffe90a3d0842d19c8beabd49fb0011"
