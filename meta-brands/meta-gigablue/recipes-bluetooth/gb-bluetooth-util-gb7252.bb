require gb-bluetooth-util.inc

COMPATIBLE_MACHINE = "gb7252"

SRCDATE = "20260730"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "172ef8517a0c22b975afbaa06b70bead"
SRC_URI[sha256sum] = "6206e1b231659b0ed056c275bb6c25bb1c2b055de6077f75c9e235365d07de23"