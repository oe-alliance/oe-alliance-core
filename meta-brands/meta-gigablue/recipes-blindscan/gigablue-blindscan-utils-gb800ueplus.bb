SRCDATE = "20150826"

SRC_URI[md5sum] = "f07acdb6c8d37784fab67420335b720d"
SRC_URI[sha256sum] = "c366975c086726c343f8dae855b82e9be2e3d2ed44ce2dfb33693a98a8f3b604"

require gigablue-blindscan-utils.inc
