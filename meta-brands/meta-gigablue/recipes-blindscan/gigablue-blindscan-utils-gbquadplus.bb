DOWNLOADMACHINE = "gbquad"
PV = "3.5.1"
PR = "r4"

SRCDATE = "20130308"

require gigablue-blindscan-utils.inc

SRC_URI[md5sum] = "671e1e0a4f031e33e87f4bb06c3c73a3"
SRC_URI[sha256sum] = "543d346d5d87816832c8d71a0e017ad11bacc136be17f5dd52cde828f4436afb"
