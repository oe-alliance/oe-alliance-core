SRCDATE = "20141217"

SRC_URI[md5sum] = "6efae2e4f052584f22b4e201b32e16ec"
SRC_URI[sha256sum] = "620fbb40c04d07350d49dae89eb490099936c053ead084569b80471f8b2d2709"

require gigablue-blindscan-utils.inc
