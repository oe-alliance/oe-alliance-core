require gigablue-platform-util.inc

SRCDATE = "20170524"

KV = "3.14.28"

SRC_URI[md5sum] = "09baeb242605b19b26bc01023afc1748"
SRC_URI[sha256sum] = "afdb4cf86c6444bbaa6d27d89ef8f187bd204738536715b837e4ed9bab03e277"
