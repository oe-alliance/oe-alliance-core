KV = "4.4.35"
SRCDATE = "20190808"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "3c749d20628379fe708b637fd1ee0cb1"
SRC_URI[sha256sum] = "af4821ad3f395bef4eda71354e82070600c7e82fd1f6d16153e6b9f59870adf8"
