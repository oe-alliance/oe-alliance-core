KV = "4.4.35"
SRCDATE = "20190216"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "14068402af59f5f7f80a3fddc880ea20"
SRC_URI[sha256sum] = "8a01f299ed5b8f973d67ac7d761df471451656b1aa7e3f18213725e99851d96f"
