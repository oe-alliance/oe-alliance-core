KV = "4.4.35"
SRCDATE = "20240301"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "295f2cbbd555e9476de258b6ec955615"
SRC_URI[sha256sum] = "d03e7415220c5da718873ddc4057f6fcd4b82f209d5a512d0ca16f8575614cd4"
