KV = "4.4.35"
SRCDATE = "20191015"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "2cbb6a3e6970a21c9245f07a2efc0b57"
SRC_URI[sha256sum] = "72355eca344ff2287ce52f2029d5318adc1570deecdeae1c0254dd3653055434"

