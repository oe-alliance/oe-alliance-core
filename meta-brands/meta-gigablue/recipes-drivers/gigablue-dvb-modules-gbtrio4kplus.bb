KV = "4.4.35"
SRCDATE = "20220929"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "86495627dbe48b957c9dd8a11f76c2f9"
SRC_URI[sha256sum] = "5cc93c888485378421ac0fb7335cb3e16b862d968dfab90dc64ac1b302e6c77d"

