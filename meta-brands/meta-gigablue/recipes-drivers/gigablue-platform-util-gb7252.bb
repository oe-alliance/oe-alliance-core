require gigablue-platform-util.inc

SRCDATE = "20261105.r0"

KV = "4.1.20"

SRC_URI[md5sum] = "40f0cc21520b1f6345fddfcded9008fe"
SRC_URI[sha256sum] = "975ec730dfc9914bbf891a3c18c3efe68a3012a190ef174e683978554fa45442"
