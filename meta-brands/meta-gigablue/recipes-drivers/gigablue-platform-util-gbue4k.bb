require gigablue-platform-util.inc

SRCDATE = "20170516"

KV = "3.14.28"

SRC_URI[md5sum] = "6a33cbc200d667d99a6951efdd3dc55c"
SRC_URI[sha256sum] = "e7da9d9eddd51ac206d9d2ba6c73706f8620a65756a48654762731133e64496b"
