require gigablue-platform-util.inc

SRCDATE = "20261105.r0"

KV = "4.1.20"

SRC_URI[md5sum] = "7fdea76f2d8e1baf6465d995781942ae"
SRC_URI[sha256sum] = "ff32a2f5c8a1436786e2401ba1722aa4522d42ad490f93c048a41cce74224cfa"
