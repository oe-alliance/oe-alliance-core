SRCDATE = "20220211"

require qviart-libs.inc

SRC_URI[md5sum] = "c6971566d9c72d2626ceb2fffdbc227a"
SRC_URI[sha256sum] = "6dd9cf96b7ad37c178aa402e068ddaff62879770a743bb438280b6aa98f87986"
