require qviart-buildimage_${PV}.bb
inherit native
