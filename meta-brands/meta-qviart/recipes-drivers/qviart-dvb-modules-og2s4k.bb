KV = "4.4.176"
SRCDATE = "20230804"

require qviart-dvb-modules-hisi.inc

SRC_URI[md5sum] = "53db1c05afea876fd9e2526b6c59fb59"
SRC_URI[sha256sum] = "273d465857890c6fb08f65df7a82fe735445f150491f03c391bd69523ad619c2"

