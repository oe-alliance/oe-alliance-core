KV = "4.4.176"
SRCDATE = "20220211"

require qviart-dvb-modules-hisi.inc

SRC_URI[md5sum] = "7e5d3416cb5c9c118e1eeba3343b817f"
SRC_URI[sha256sum] = "3bc34dd753617bf46797b86875a53f53ac4710a6dcda5aeea4267dc66c6c7a56"

