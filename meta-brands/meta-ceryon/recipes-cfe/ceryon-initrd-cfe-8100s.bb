SRCDATE = "20170526"

require ceryon-initrd-cfe.inc

SRC_URI[md5sum] = "a1ccb789ab2512e2ff40b396c6bfdc1d"
SRC_URI[sha256sum] = "e36523cfd03945dbe958bf4e53a3bcc342742ccd303bad0436fd97453c5dc376"
