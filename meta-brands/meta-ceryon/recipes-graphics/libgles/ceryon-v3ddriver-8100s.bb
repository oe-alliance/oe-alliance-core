SRCDATE = "20250217"

require ceryon-v3ddriver.inc

SRC_URI[md5sum] = "30fac066aaff6fb05adf81bb570a4f7a"
SRC_URI[sha256sum] = "fc06f47c9791c3aea0d696e1c04e2a2af950beca493bcfa563968b94d23d1a19"

COMPATIBLE_MACHINE = "8100s"
