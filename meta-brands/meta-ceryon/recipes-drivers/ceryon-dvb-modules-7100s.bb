KV = "3.14.2"
SRCDATE = "20151027"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "4968a4392db0d8c2e3ea631db4bbd693"
SRC_URI[sha256sum] = "3034b51e692501f98daeae629abfa8958abb851e875e58b448ea8fd01ece82b0"
