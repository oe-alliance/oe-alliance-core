KV = "4.0.1"
SRCDATE = "20161213"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "31cd371b829a6174bd2100de7f8c85d7"
SRC_URI[sha256sum] = "3c46607ad6572268dc02a551c79e669e7a3f2af9d0698b330b2eecaecf4b83c6"
