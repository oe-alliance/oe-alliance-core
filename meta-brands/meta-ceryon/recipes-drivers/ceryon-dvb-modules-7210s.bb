KV = "4.0.1"
SRCDATE = "20160711"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "bdca750e763a43e9a02cd69113aca519"
SRC_URI[sha256sum] = "9b513d3034ca9224794cfc217300e96722cbe558e5651b5912e308ea20ae61f7"
