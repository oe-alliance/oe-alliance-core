KV = "4.10.12"
SRCDATE = "20250429"

require ceryon-dvb-modules-oem.inc
SRC_URI[md5sum] = "7985d9beb8394b0e5997c12d4250e8eb"
SRC_URI[sha256sum] = "ab0a6a95d98479d4258bae98a53513bb59539e180c47e621d4e95acc66b23041"
