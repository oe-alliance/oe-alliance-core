KV = "3.14.28-1.12"
SRCDATE = "20170524"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "dd6bede4764160f796e923b6523dec00"
SRC_URI[sha256sum] = "ed412b3ce1d5ee7e6ede167d3fcaf3fae8bf70319693887a5c36bf3ba4067b62"
