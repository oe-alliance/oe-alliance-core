KV = "4.0.1"
SRCDATE = "20160913"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "386b64460e4e12a79be90b2da51fbd3f"
SRC_URI[sha256sum] = "3012069e8764ecbfa6ba4697b2a790f2e9d04df0910cd33c7d9777b563758cf6"
