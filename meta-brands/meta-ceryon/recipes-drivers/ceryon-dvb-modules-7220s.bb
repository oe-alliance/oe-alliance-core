KV = "4.0.1"
SRCDATE = "20190222"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "d78eabdabf4ad3649a2a4178ee5a5bf0"
SRC_URI[sha256sum] = "26f9a17367b71d602f723a94be2f5500f0b3e5a6c15f0b4583eb432570885a21"
