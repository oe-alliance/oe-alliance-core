KV = "3.14.2"
SRCDATE = "20150408"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "f255622b866f0202cdae095ce38d6c43"
SRC_URI[sha256sum] = "f718a5ebe2265ba7d8bc674acabbace5374ca585cf74afc40de322af6602be9d"
