KV = "4.10.12"
SRCDATE = "20250429"

require ceryon-dvb-modules-oem.inc
SRC_URI[md5sum] = "4caf878f38f1d3869dbdb9b2627254ba"
SRC_URI[sha256sum] = "b60b4e69450cbbed80e8ea89d68c34ea1f7cfde8bb7d69f813a01349dede21cf"
