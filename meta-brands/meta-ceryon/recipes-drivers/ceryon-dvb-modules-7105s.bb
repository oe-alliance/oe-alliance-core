KV = "4.0.1"
SRCDATE = "20160706"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "afe1f0f701f04209440c545653942923"
SRC_URI[sha256sum] = "7d9082303a6452836667fbbe94034ed89e8ba9dbfb02e08efd92aba7af84e2e6"
