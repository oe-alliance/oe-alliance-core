KV = "4.0.1"
SRCDATE = "20160428"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "5fdc8b4e862a32ef40f82554555a3c83"
SRC_URI[sha256sum] = "3bf23c6d6520d6e371bd6ae3acf8fa56064b81036c7b32d407cfaa2e56b23ff5"
