SRC_URI[dreamone.md5sum] = "a9a7d0ff39d670bda7086b8c679415fe"
SRC_URI[dreamone.sha256sum] = "1f12f567b3868298e36300cee80b8f7953eff0339cdf97fb459da346a9959abb"
SRC_URI[dreamtwo.md5sum] = "f0a701f97f27991aa578899da343ca91"
SRC_URI[dreamtwo.sha256sum] = "85d63a173d2140000a1764065535e671fcf37d34488bf4ba3cb50eaf2cc4f713"

inherit opendreambox-precompiled-binary4

require u-boot-bin.inc
