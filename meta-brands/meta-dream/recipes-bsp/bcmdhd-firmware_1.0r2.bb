SRC_URI[all.md5sum] = "3815bf87c0c39c63de32db99f02827ba"
SRC_URI[all.sha256sum] = "9b36fa0981ec605e13372aff4a1cba7a0f4cb632d26de0967302624870449ce3"
PRECOMPILED_ARCH = "all"

inherit opendreambox-precompiled-binary4

require bcmdhd-firmware.inc
