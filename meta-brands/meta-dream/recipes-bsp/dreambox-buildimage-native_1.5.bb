require dreambox-buildimage_${PV}.bb
inherit native
