CURRENT_FW = "dm9x0dongle-central-200226-1.11.hex"

include nrf52-firmware.inc

COMPATIBLE_MACHINE = "^(dm900|dm920)$"


