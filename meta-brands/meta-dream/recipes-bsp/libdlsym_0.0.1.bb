SUMMARY = "Helper library to link against preloadable libraries"
SECTION = "base"
LICENSE = "CLOSED"
SRCREV = "235cb0926c37b25f4509f9e5ab89431d4c46a6c3"
PR = "r0"

inherit autotools opendreambox-git lib_package pkgconfig
