KV = "3.4-4.0"
DRIVERDATE = "20170425"

require dreambox-dvb-modules-dm820.inc

SRC_URI[dm820.md5sum] = "cc22acd18865efcf0edeadb6b0c12934"
SRC_URI[dm820.sha256sum] = "50b696033090759768aa8590b2086f7055f3e0e7f3f4d585475ed8885ab69852"

COMPATIBLE_MACHINE = "^(dm820)$"