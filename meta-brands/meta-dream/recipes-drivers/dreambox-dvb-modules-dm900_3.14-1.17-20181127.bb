KV = "3.14-1.17"
DRIVERDATE = "20181127"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "ef6986307b6c499ae0b1a9a69129fb87"
SRC_URI[dm900.sha256sum] = "50ae594b9835e4ba27800a6c64fdd710ac71725fee55164583352cb1d33c4ca7"

COMPATIBLE_MACHINE = "^(dm900)$"
