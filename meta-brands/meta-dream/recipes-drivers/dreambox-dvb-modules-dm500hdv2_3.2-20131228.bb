require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "503cba79c93835faf1de9244875a19ef"
SRC_URI[modules.sha256sum] = "969ef2c4417de122131ba434ff6e43fecd85d469ca198fd4e889f7c0ca153fec"
