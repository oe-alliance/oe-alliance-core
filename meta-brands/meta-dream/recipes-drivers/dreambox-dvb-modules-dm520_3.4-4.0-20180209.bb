KV = "3.4-4.0"
DRIVERDATE = "20180209"

require dreambox-dvb-modules-dm520.inc

SRC_URI[dm520.md5sum] = "ddf560b7260c73e77156e85f31709cf3"
SRC_URI[dm520.sha256sum] = "d469c5e522f422a60fd223f7978ae80c10705126ceb0eeaa53604370c1408bea"

COMPATIBLE_MACHINE = "^(dm520)$"