KV = "3.14-1.17"
DRIVERDATE = "20170510"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "36260a601b78b8a0eccf1d76d8f3e3ae"
SRC_URI[dm900.sha256sum] = "b54cff5989283eb689ef65fe05bc8746ccf6b0f1e01e2aa0052aa9c42a84fb5b"

COMPATIBLE_MACHINE = "^(dm900)$"
