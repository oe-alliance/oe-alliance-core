require dreambox-dvb-modules.inc

PR = "${INC_PR}.2"

SRC_URI[modules.md5sum] = "83950a076306cad84d029f1672c53ad0"
SRC_URI[modules.sha256sum] = "8092f57d58295c407424ccdfac536b6ec597059dff9a913a55e704af91983d3e"


