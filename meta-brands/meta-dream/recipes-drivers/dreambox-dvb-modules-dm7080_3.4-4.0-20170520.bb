KV = "3.4-4.0"
DRIVERDATE = "20170520"

require dreambox-dvb-modules-dm7080.inc

SRC_URI[dm7080.md5sum] = "baff901323bc291fd82255095fa63659"
SRC_URI[dm7080.sha256sum] = "78de6b265848b41aeccc89074e315c2e1749f04dbb1952d78a214d8c62ead0ce"

COMPATIBLE_MACHINE = "^(dm7080)$"