KV = "3.4-4.0"
DRIVERDATE = "20180209"

require dreambox-dvb-modules-dm820.inc

SRC_URI[dm820.md5sum] = "0eb452838540a166b75139b4f4577cba"
SRC_URI[dm820.sha256sum] = "f3ef98df5c0d30b4a43af7bb3a3b36eb1c6efea3665d35f5f9cca0148783a97a"

COMPATIBLE_MACHINE = "^(dm820)$"