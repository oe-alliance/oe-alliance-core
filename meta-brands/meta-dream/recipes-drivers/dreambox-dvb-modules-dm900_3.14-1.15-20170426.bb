KV = "3.14-1.15"
DRIVERDATE = "20170426"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "0438be8d49034e88e9798b0c216a0ffb"
SRC_URI[dm900.sha256sum] = "e229c4840b476d732e1840d75a06cf79eaf735f1b7b35903c302eb58b47ff145"

COMPATIBLE_MACHINE = "^(dm900)$"
