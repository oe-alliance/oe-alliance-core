KV = "3.14-1.17"
DRIVERDATE = "20171211"

require dreambox-dvb-modules-dm920.inc

SRC_URI[dm920.md5sum] = "9c55bb8c6322429968b9f46bd767dd59"
SRC_URI[dm920.sha256sum] = "d4e0c3963570291f6ab10959cce60c6cc06df784d5cb4aa4331559bbf5abe93b"

COMPATIBLE_MACHINE = "^(dm920)$"
