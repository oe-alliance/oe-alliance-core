require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "4a1409947dccd10a89c64c7fec54240d"
SRC_URI[modules.sha256sum] = "195585f998de8a80be3a3c6da3978bf1edbbb5bc70ab0a0054d2035b8178fc07"