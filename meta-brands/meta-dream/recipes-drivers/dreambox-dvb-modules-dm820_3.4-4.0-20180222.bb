KV = "3.4-4.0"
DRIVERDATE = "20180222"

require dreambox-dvb-modules-dm820.inc

SRC_URI[dm820.md5sum] = "b5baac727775dd7bb6f1db51b6a4d18c"
SRC_URI[dm820.sha256sum] = "2bedc4ee53abfeabb34040de15bc52338aa98668018e60ed96835a925bf9f70f"

COMPATIBLE_MACHINE = "^(dm820)$"