KV = "3.14-1.17"
DRIVERDATE = "20170717"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "bf6103d4dca35d92ec7ea7c9c0a58311"
SRC_URI[dm900.sha256sum] = "0758a5621f3ddf2d9f88c2f2da68e9e5e65a8843a4f34362651e9dbee3ab372f"

COMPATIBLE_MACHINE = "^(dm900)$"
