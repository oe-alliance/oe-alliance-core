COMPATIBLE_MACHINE = "^(dm800sev2)$"

require dreambox-dvb-modules.inc

PR = "${INC_PR}.2"

SRC_URI[modules.md5sum] = "b17d215333da3d43e3f8fd6a69462077"
SRC_URI[modules.sha256sum] = "6bed413c13b53b178cbbcfb91522145443d74a4230bb7be6b8b735351579e3e6"
