KV = "3.14-1.17"
DRIVERDATE = "20170520"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "747e187fceba369f61666a0d6f9c1b1a"
SRC_URI[dm900.sha256sum] = "de14a5204e1a1bb5e65ae22c78ac2b2024703ca5692c5c1761e2c0662a25eb27"

COMPATIBLE_MACHINE = "^(dm900)$"
