require dreambox-dvb-modules.inc

PR = "${INC_PR}.3"

SRC_URI[modules.md5sum] = "91fe65fccb79c5bbf66be025dc85bc33"
SRC_URI[modules.sha256sum] = "bd6259e4618f93009f26c57ebfd3986014e0a17bce45be95dd716694b9cfad49"
