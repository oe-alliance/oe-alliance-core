KV = "3.4-4.0"
DRIVERDATE = "20170520"

require dreambox-dvb-modules-dm820.inc

SRC_URI[dm820.md5sum] = "28e4f26c0e361f3d4f3df75829961642"
SRC_URI[dm820.sha256sum] = "c4f60a89b71a3fb819c2e217003c13f0b0292208e5d52089bb87b9de815a7b99"

COMPATIBLE_MACHINE = "^(dm820)$"