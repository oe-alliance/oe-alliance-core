KV = "3.14-1.17"
DRIVERDATE = "20170710"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "4cf8500caac736a8855e399b089a7c07"
SRC_URI[dm900.sha256sum] = "4c2e3f49a8fedd3bbe001e3c2ac497961ce5500e12087ec3f64e9664caeae1f9"

COMPATIBLE_MACHINE = "^(dm900)$"
