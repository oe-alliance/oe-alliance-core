KV = "3.14-1.17"
DRIVERDATE = "20180425"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "b12caad8e61a55aefcdbb414c4fa9197"
SRC_URI[dm900.sha256sum] = "415b1b705cfdd067828f36306ca5016cb465a6141e58f653cd3be942a2354f04"

COMPATIBLE_MACHINE = "^(dm900)$"
