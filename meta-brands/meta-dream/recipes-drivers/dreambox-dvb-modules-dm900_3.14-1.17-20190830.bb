KV = "3.14-1.17"
DRIVERDATE = "20190830"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "215a0b7ccbe355b5be8b7bd36b4400ae"
SRC_URI[dm900.sha256sum] = "92e59bda05c3316e31994e37259f42e28bfb73eb8b3e3778ba47d6e63b0dcac3"

COMPATIBLE_MACHINE = "^(dm900)$"
