require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "f27a33ae50f8b7afdb8a78d08048fe1a"
SRC_URI[modules.sha256sum] = "328f8e8c93d637b383b8beb38d5f25f3b235dcdaea50d0c5e5e481c5561c9567"
