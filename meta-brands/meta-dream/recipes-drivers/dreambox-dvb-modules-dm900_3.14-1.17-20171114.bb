KV = "3.14-1.17"
DRIVERDATE = "20171114"

require dreambox-dvb-modules-dm900.inc

SRC_URI[dm900.md5sum] = "c9a31ae67dfe36ddc73eeae8de1a9415"
SRC_URI[dm900.sha256sum] = "500ea488397f0fa234af4fbdc21c03911fdcf6df5e83073cb21d758c13755b8d"

COMPATIBLE_MACHINE = "^(dm900)$"
