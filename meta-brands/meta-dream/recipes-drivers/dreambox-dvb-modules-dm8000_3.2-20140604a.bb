COMPATIBLE_MACHINE = "^(dm8000)$"

require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "ed55fd9ef298cd582e1f08322c8d9649"
SRC_URI[modules.sha256sum] = "3a11801794c7ac7cf04be41c65591bb2e81f4c6b08c1f33c86d17154f08f16be"
