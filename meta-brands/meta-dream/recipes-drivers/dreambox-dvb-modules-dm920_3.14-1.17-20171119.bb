KV = "3.14-1.17"
DRIVERDATE = "20171119"

require dreambox-dvb-modules-dm920.inc

SRC_URI[dm920.md5sum] = "f594d740acb7674400dbc25a4081a426"
SRC_URI[dm920.sha256sum] = "10ea07a8c285983c2cae7d550d0d71ee94c1507419fd1da07e1ea88e855c64cd"

COMPATIBLE_MACHINE = "^(dm920)$"
