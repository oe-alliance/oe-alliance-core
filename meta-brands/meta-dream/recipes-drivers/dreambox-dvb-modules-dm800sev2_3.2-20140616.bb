require dreambox-dvb-modules.inc

PR = "${INC_PR}.2"

SRC_URI[modules.md5sum] = "99fed09a4b120cb26ed26da406741e38"
SRC_URI[modules.sha256sum] = "a40eef5ede3afd86402acfd0a0d13fd5fa2eaee1b95bcfd878fb606df2e6668a"


