KV = "3.4-4.0"
DRIVERDATE = "20170425"

require dreambox-dvb-modules-dm7080.inc

SRC_URI[dm7080.md5sum] = "d6989c9f0d46df7a7b19ace65c1c7f88"
SRC_URI[dm7080.sha256sum] = "b919781a40c18e4df0a6c11f67e8d5c05ec679a401eb3626df23d5ea43342b06"

COMPATIBLE_MACHINE = "^(dm7080)$"