KV = "3.14-1.17"
DRIVERDATE = "20171206"

require dreambox-dvb-modules-dm920.inc

SRC_URI[dm920.md5sum] = "3e90b7736d10bdcb8bf6bf3bd4e745a5"
SRC_URI[dm920.sha256sum] = "6c25d82b12689d20a06770683a39335324e93eeb8ed0968907dc638eabaec91a"

COMPATIBLE_MACHINE = "^(dm920)$"
