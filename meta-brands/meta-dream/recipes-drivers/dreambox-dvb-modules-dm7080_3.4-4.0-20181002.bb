KV = "3.4-4.0"
DRIVERDATE = "20181002"

require dreambox-dvb-modules-dm7080.inc

SRC_URI[dm7080.md5sum] = "65ed9535b7fb17602119919afd9bcbd3"
SRC_URI[dm7080.sha256sum] = "33a9b8dad0a1a40c5fc8879c9581ae74289a7a81cd1d274d39f1fea7a8067417"

COMPATIBLE_MACHINE = "^(dm7080)$"