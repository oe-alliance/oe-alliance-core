KV = "3.14-1.17"
DRIVERDATE = "20190312"

require dreambox-dvb-modules-dm920.inc

SRC_URI[dm920.md5sum] = "26d1ac50f18975037d4e6f7c7c18fdff"
SRC_URI[dm920.sha256sum] = "4b94b35349266cb5c3484cfb12209a50c98409cc675738faa74abd06a628950e"

COMPATIBLE_MACHINE = "^(dm920)$"
