KV = "3.4-4.0"
DRIVERDATE = "20170425"

require dreambox-dvb-modules-dm520.inc

SRC_URI[dm520.md5sum] = "4a12236599ded4d847e224d1ff5c1e3f"
SRC_URI[dm520.sha256sum] = "21755f248edf7cc7a87dbba3b0b2835e8105db715048c0924c4b66b64282dc66"

COMPATIBLE_MACHINE = "^(dm520)$"