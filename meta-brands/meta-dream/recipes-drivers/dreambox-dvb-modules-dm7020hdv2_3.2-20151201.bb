PRECOMPILED_ARCH = "dm7020hd"

require dreambox-dvb-modules.inc

PR = "${INC_PR}.3"

SRC_URI[modules.md5sum] = "59f2e25933859a8de35c684b4feefb68"
SRC_URI[modules.sha256sum] = "9cab76ab78055f9169cf84699667a666843c714f9b73f45b231fcf507bc8a8b1"
