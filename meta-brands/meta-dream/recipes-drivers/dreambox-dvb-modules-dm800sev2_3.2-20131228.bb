require dreambox-dvb-modules.inc

PR = "${INC_PR}.2"

SRC_URI[modules.md5sum] = "b9f3666c57ce9e9923da3514d06c3db6"
SRC_URI[modules.sha256sum] = "b35806c088d4e599878ed2add1fedb2758b1a1fd6e3ed3038e2be60a3d524116"


