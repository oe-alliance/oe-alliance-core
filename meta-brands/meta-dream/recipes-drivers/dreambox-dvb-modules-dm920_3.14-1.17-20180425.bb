KV = "3.14-1.17"
DRIVERDATE = "20180425"

require dreambox-dvb-modules-dm920.inc

SRC_URI[dm920.md5sum] = "101ff0ba3caebd0a7f8f2bddaff05313"
SRC_URI[dm920.sha256sum] = "32d20cd62db357f23de34affde7a1d125164561a4a935fe5e08b24bb6b172e30"

COMPATIBLE_MACHINE = "^(dm920)$"
