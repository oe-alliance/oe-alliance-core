KV = "3.14-1.17"
DRIVERDATE = "20180409"

require dreambox-dvb-modules-dm920.inc

SRC_URI[dm920.md5sum] = "e790932031d2093aaabfdd97394ab356"
SRC_URI[dm920.sha256sum] = "1b470128a09c0d36b33f43c6a9b4c6f7aa89d34b11bc029167d9c7259fa1b617"

COMPATIBLE_MACHINE = "^(dm920)$"
