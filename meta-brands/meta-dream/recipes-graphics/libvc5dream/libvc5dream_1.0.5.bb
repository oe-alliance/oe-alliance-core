require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "ab90073665c58598fea18039c99b211a"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "5f76330975369cd20ef9e6d4ed03daa60694aea3cdf2d425fdb1d434ff68b534"
SRC_URI[mips32el.md5sum] = "b72e651aaa6a67ccdc973b609b6451ca"
SRC_URI[mips32el.sha256sum] = "cb3568a58964e110531619a6012315ad70bb62f095c7ee4a0b2b20cf66b08fff"

inherit opendreambox-precompiled-binary3
