require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "7211f9fe1680602915f8e9d696a7b054"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "7617fe4601bc53f60c7b7255deba66d98e158572a239f267e8de4bb4bce74157"
SRC_URI[mips32el.md5sum] = "6191b7319003aaf05b01064a97031c78"
SRC_URI[mips32el.sha256sum] = "d8d48314d2c2d27f2c864fda2682ae766e97942d3876d822807b3609524287f0"

inherit opendreambox-precompiled-binary3
