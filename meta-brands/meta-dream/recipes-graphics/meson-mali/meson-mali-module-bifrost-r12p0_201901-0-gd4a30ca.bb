require meson-mali-module.inc

SRC_URI = "https://dreamboxupdate.com/download/opendreambox/${BPN}/${BPN}-${PV}.tar.xz"
SRC_URI[md5sum] = "c276095302b514fa698bdcf2d740a039"
SRC_URI[sha256sum] = "e82413755ecd77a183acd09a55198b3d984478e91d9da49bdb811fdf617abab0"
