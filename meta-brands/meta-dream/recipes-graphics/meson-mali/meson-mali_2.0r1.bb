SRC_URI[aarch64.md5sum] = "e608bbc6254c302e8264f11119f79f6d"
SRC_URI[aarch64.sha256sum] = "ba238397849c115046fd269e47209a95ce41e4e88140a23b0eea166c66fc2422"

inherit opendreambox-precompiled-binary4

require meson-mali.inc
