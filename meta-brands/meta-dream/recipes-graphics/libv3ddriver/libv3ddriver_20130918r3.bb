require libv3ddriver.inc

SRC_URI[mips32el.md5sum] = "bc8608430b20ed65260be268b3db89a0"
SRC_URI[mips32el.sha256sum] = "3daa50dd2750770f727bf8599703ea3ff0f19f23f6623453051fc29d9a6ca5eb"

inherit opendreambox-precompiled-binary3
