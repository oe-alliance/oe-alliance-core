PRECOMPILED_ARCH = "dm7020hd"

require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "61940d88fa99757a4ff1705a14fad3ee"
SRC_URI[sha256sum] = "f11dd4e990d32629d66d35131569532ddc91592bb85e0cf78bc2e7de0aaebfc6"
