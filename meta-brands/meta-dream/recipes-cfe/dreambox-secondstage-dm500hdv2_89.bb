require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "834a559814ca3125814464a027cbc12d"
SRC_URI[sha256sum] = "ad77fdd24808af3ffdcbc0373da09340ecc9cd938719eef966e2360a2e2fae95"
