KV = "2.6.34"
SRCDATE = "20141203"

require e2bmc-dvb-modules.inc

SRC_URI[md5sum] = "724ca6e6d4e919e6d34f1b89cc7f9762"
SRC_URI[sha256sum] = "65a14db6c23f14e8cbc89231ecafb5bf7d8e1a7b0b6b2da5fd472086839bf123"
