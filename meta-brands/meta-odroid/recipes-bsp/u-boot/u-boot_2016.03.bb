require u-boot.inc

DEPENDS += "dtc-native"

