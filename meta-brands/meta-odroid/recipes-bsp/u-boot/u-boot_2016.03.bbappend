
UBOOT_MACHINE_odroid-xu3 = "odroid-xu3_defconfig"
RDEPENDS_${PN} = "secure-odroid-xu3"
