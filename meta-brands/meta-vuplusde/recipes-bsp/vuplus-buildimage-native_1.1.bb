require vuplus-buildimage_${PV}.bb
inherit native
