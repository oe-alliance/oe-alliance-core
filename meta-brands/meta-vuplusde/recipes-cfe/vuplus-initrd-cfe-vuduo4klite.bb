SRCDATE = "20260729r0"

require vuplus-initrd-cfe.inc

SRC_URI[md5sum] = "813089ee777dfd95934e35019c1f9ef6"
SRC_URI[sha256sum] = "c85f08d55a00586f9265ecdd5eed7ede8dfe2596de2ae7dbdc335002563d420a"
