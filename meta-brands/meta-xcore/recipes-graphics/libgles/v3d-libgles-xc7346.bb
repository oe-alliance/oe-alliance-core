SRCDATE = "20151201"
SRCDATE_PR = "r0"

require v3d-libgles.inc
