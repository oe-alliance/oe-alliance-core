SRCDATE = "20151201"

require xcore-v3ddriver.inc
