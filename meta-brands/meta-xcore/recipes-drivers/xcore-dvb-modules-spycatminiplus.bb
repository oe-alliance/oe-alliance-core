KV = "4.9.0"
SRCDATE = "20161229"
KOFILES = "brcmstb-${MACHINE_DRIVER} ftm4862 fts260 sp988x sp968x"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "132ec10d737b3edf025cb2343e55efd5"
SRC_URI[sha256sum] = "982ca68bcd7c2d0fd3ca71aac0e609a1779d779ed081a6a970c1d83bc28cb39c"
