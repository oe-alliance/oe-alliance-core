KV = "4.11.0"
SRCDATE = "20170505"
KOFILES = "brcmstb-${MACHINE_DRIVER} ci ftm4862 fts260 sp988x"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "5287bc2626896716c7619d103880387b"
SRC_URI[sha256sum] = "fddfa6ca85c870b6dfa1f152f255ae1b890f664482f055152c110a8b507c6647"
