KV = "4.0.2"
SRCDATE = "20150510"
KOFILES = "brcmstb ci"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "405a347dbd6032ba9c2eb4a2f9d40038"
SRC_URI[sha256sum] = "034e27841b1ef33df07a2a987c264839e0b0338fda332e8d9fbfb6f543ce6113"
