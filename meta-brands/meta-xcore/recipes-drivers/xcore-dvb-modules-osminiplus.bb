KV = "4.5.0"
SRCDATE = "20160401"
KOFILES = "brcmstb-${MACHINE_DRIVER} ftm4862 fts260 mn88473"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "396416935a67bb882d2552612aa371e5"
SRC_URI[sha256sum] = "e3e75d848a20416375000467838dd74021d1e490b1af5aecbfe21aefb5f441a4"
