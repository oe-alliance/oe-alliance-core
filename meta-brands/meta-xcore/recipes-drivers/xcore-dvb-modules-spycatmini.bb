KV = "4.8.0"
SRCDATE = "20161207"
KOFILES = "brcmstb-${MACHINE_DRIVER} fts260 sp988x sp968x"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "2c0fa8ed9800ff71c62c93115689d08c"
SRC_URI[sha256sum] = "94261b64866995c196217184669eef8945ffa5bf591288ee355e0809245de44a"
