KV = "4.9.0"
SRCDATE = "20170215"
KOFILES = "brcmstb-${MACHINE_DRIVER} ci ftm4862 fts260 sp988x sp968x"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "7be32f4cddc32e6a9ad2633abca7e2bc"
SRC_URI[sha256sum] = "448dbe14a6ac48ed3de4a3b4523e74bbcf2016d8da611986b6ab108671c7950d"
