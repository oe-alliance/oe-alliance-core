KV = "4.0.0"
SRCDATE = "20150508"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "472c2a1e26f7c2b7a5abac44c4e81049"
SRC_URI[sha256sum] = "69295e0322d9b31461a1f57401a6959753549b27257c14d267f48ecee23471db"
