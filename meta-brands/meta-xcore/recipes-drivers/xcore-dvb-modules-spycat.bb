KV = "4.3.0"
SRCDATE = "20151109"
KOFILES = "brcmstb-${MACHINE_DRIVER} ci fts260 mn88472 mn88473"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "507124c0c83c6a24165624d45a88f6ba"
SRC_URI[sha256sum] = "38bfd821ea32626d8e5ce1df841eae6d86bd4649862f025bd48785cab68595a9"
