KV = "4.8.0"
SRCDATE = "20161205"
KOFILES = "brcmstb-${MACHINE_DRIVER} ci ftm4862 sp968x sp988x"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "cbed7134810f8015a1026bf5d9f62e44"
SRC_URI[sha256sum] = "9017a900a142d6ea57f8d7b5ad0f0eafab476b370721a0231ba65c5e364ff12b"
