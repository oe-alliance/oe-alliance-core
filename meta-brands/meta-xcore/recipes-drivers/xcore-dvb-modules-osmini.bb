KV = "4.9.0"
SRCDATE = "20161229"
KOFILES = "brcmstb-${MACHINE_DRIVER} fts260 sp988x sp968x"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "2b0e3a67ff9221a72f36032613c82eb0"
SRC_URI[sha256sum] = "a1ee60f9b936c339def7f68fe5dd4e16a6f12428d4a69dae79960952f5096431"
