KV = "4.0.2"
SRCDATE = "20150510"
KOFILES = "brcmstb ci"

require xcore-dvb-modules.inc
SRC_URI[md5sum] = "2bb82bbba85058b21ef9dba2b9fe7847"
SRC_URI[sha256sum] = "eadd28952af935244e41b379a1bfa123674e27a121a8b48bde469e01e409bd7c"
