require wetek-libamadec.inc

S = "${WORKDIR}/libamcodec-75f23da/amadec"

SRC_URI_wetekplay = "file://libamcodec-75f23da.tar.gz;md5=2ff1cbc415271733e1241e8cde0b105e \
           file://audiodsp_codec_ddp_dcv.bin \
           file://libamadec.pc \
"