require wetek-libamavutils.inc

S = "${WORKDIR}/libamcodec-210755d/amavutils"

SRC_URI = "file://libamcodec-210755d.tar.gz;md5=d2e7dc15302fa64eef54aa67da5f9f34"