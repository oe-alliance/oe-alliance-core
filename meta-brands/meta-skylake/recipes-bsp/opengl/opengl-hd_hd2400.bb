require opengl-hd.inc

COMPATIBLE_MACHINE = "^(hd2400|formuler1)$"
