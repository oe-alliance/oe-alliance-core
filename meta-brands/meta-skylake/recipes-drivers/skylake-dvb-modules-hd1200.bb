KV = "4.0.0"
SRCDATE = "20150413"

require skylake-dvb-modules.inc
SRC_URI[md5sum] = "d80e4ceb3af63090f93e658c1ecec416"
SRC_URI[sha256sum] = "28bc58d38a087e909c97f9bdca3358136da5e17915d55ae3bfc1565c02f1724f"
