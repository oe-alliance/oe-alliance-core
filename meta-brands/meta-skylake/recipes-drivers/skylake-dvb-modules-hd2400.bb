KV = "4.7.3"
SRCDATE = "20160921"

require skylake-dvb-modules.inc
SRC_URI[md5sum] = "6810ae69fe06f885db9542489ae91753"
SRC_URI[sha256sum] = "feb193bb21d870cdd9ead2975db15a0b1c9062c0afe626a10177004d64aad429"
