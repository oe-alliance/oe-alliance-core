KV = "4.0.1"
SRCDATE = "20151128"

require skylake-dvb-modules.inc
SRC_URI[md5sum] = "617d63d1c9989a85870b75aa02bcb855"
SRC_URI[sha256sum] = "1c856d44a531ca709f6aaaee79c7098192d6efe5c2b457c681206ef43d3418d1"
