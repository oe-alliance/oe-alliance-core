KV = "4.0.1"
SRCDATE = "20150807"

require skylake-dvb-modules.inc
SRC_URI[md5sum] = "be70ea4464633e2208e81862d71e9fe0"
SRC_URI[sha256sum] = "e9c5a63a8b04630a3b25d6472b765f401ed61721b4370636edc51ec9680f2d7c"
