KV = "4.0.1"
SRCDATE = "20150807"

require skylake-dvb-modules.inc
SRC_URI[md5sum] = "309a299695d026443627e2986b639328"
SRC_URI[sha256sum] = "52a3bf1048dc525b88fd01a41562796ce681775322ed8367f1f9dafd73506918"
