SRCDATE = "20170322"

require skylake-v3ddriver.inc

SRC_URI[md5sum] = "d82984240fad7253845c75be4371ee90"
SRC_URI[sha256sum] = "fce2c9970c509a1a9bc0ddc969f82166b51ffded3918eda5aa2a3f1e2fcda0c9"

COMPATIBLE_MACHINE = "hd2400"