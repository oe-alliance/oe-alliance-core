KV = "4.0.1"
SRCDATE = "20160127"

require ax-dvb-modules.inc
SRC_URI[md5sum] = "2d0513aff141d05ef85d383e0460b905"
SRC_URI[sha256sum] = "2fea6a2d2ed57863a59b9e9c6fc64ed1028dfe0716fdebed76388ac8ac160d1b"
