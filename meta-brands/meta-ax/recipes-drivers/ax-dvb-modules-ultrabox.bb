KV = "4.7.6"
SRCDATE = "20161005"

require ax-dvb-modules.inc
SRC_URI[md5sum] = "6b7a305ac7ddd5cb6ee959505f1f97e8"
SRC_URI[sha256sum] = "39a4c74cbff666b0dd9ec16e717c5bb2499b45571a3a6603cfc4237b5555cdaa"
