SRCDATE = "20170322"

require ax-v3ddriver.inc

SRC_URI[md5sum] = "ffa9d1c01afa35f551ccc31a74d9f567"
SRC_URI[sha256sum] = "ce7a7be0da4a214bccde24f4e4b5b66f48704c845ae6f4c990f3358c9b118f3f"

COMPATIBLE_MACHINE = "triplex"