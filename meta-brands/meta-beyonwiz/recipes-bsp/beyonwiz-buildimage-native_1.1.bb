require beyonwiz-buildimage_${PV}.bb
inherit native
