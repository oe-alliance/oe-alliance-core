KV = "4.4.35"
SRCDATE = "20250218"

require beyonwiz-dvb-modules-hisi.inc

SRC_URI[md5sum] = "c62003f8eb1727b5cd1fafc2cc26ab4f"
SRC_URI[sha256sum] = "ee5ead2284565c2583c4b9075c2e2c7de6da8131b5c9f3b7024afdb1259049a4"

