SRCDATE = "20190402"

require beyonwiz-libs.inc

SRC_URI[md5sum] = "5af4077161ac107f5dc42c7661021b6e"
SRC_URI[sha256sum] = "ba51292674337904c2d97b1b098791d874461a3ba57656361e3f5e4b95ce0926"
