KV = "4.1.15"
SRCDATE = "20160126"

require broadmedia-dvb-modules.inc
SRC_URI[md5sum] = "4cc164814db25c894c8af4a9e0b2f358"
SRC_URI[sha256sum] = "b177debe5a938eaba2f71a7c56788728622f448918185c17a2aa4bb340cb3e83"
