KV = "4.1.15"
SRCDATE = "20160126"

require broadmedia-dvb-modules.inc
SRC_URI[md5sum] = "99d3965ebcd04aee839159be1e25632a"
SRC_URI[sha256sum] = "5ce82de22751251fc87c88aaf51ca6e0f5265b974283039cc5e970e1108ddfe1"
