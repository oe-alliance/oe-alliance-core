KV = "4.1.24"
GCCREV = "6.3.0"
SRCDATE = "20170424"

require broadmedia-dvb-modules.inc
SRC_URI[md5sum] = "2dd43c027dc1df8b2bf05de123a54ddf"
SRC_URI[sha256sum] = "97297e09bf66336c99277f2f70f6819b330775f835d1b565a828bc2d99124725"
