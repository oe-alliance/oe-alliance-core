KV = "3.17.8"
SRCDATE = "20150319"

require broadmedia-dvb-modules.inc
SRC_URI[md5sum] = "9881daf45dfd5addcb89eb2a44e58b77"
SRC_URI[sha256sum] = "60f5ad6159fd84a4602fee55b4f2cae25b0dbbaf8360ea91f95556ab92fc2b09"
