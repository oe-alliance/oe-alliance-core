KV = "4.1.24"
GCCREV = "5.3.0"
SRCDATE = "20161215"

require broadmedia-dvb-modules.inc
SRC_URI[md5sum] = "b72ed862ebd6c437842613618a9ea75e"
SRC_URI[sha256sum] = "85a98bc0a13bf7ce6680d7477e8b14f2fcd83d4064a2276bddd5b5364d1ab293"
