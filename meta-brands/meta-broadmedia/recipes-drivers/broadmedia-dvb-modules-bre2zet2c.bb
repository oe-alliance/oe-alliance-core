KV = "4.1.24"
GCCREV = "5.3.0"
SRCDATE = "20161215"

require broadmedia-dvb-modules.inc
SRC_URI[md5sum] = "a8e07abdb23c56e9edaeaebb70e6d860"
SRC_URI[sha256sum] = "326a4b6780a276879dc07cc87faa68a8d78805eb88444f7425d609f2b5da4ab5"
