KV = "3.9.6"
SRCDATE = "20151117"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "cae0ff3061d46e28f321a36d30b7fa13"
SRC_URI[sha256sum] = "8ff4f59e17177ae3f4be425a8bf8258ff1dd07b6a96f7946f31de9e878faaec1"
