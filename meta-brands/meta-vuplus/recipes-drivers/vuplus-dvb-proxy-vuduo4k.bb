PV = "4.1.45"
KV = "${PV}-1.17"
SRCDATE = "20250706"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "4ac3cd137d81f3aa8bbcb372ba5ca411"
SRC_URI[sha256sum] = "c31ab1560810d331ea23eb1a104ffe3ab4ba8e959213ef4f66041ace19d4c797"
