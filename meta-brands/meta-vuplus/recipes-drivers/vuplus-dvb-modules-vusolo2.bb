KV = "3.13.5"
SRCDATE = "20161130"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "ea7140614156b898314e0b4c4aa73f8b"
SRC_URI[sha256sum] = "a6a1d7ae20f775f9c33301eb2936c6fc31efc0ae0720300c60fb657449459d3c"
