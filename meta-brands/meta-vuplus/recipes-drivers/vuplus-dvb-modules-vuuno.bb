KV = "3.9.6"
SRCDATE = "20151117"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "f5c67ee111746ce463a2d9de62a74fb0"
SRC_URI[sha256sum] = "404ddd3860dba884ffe6be2c9feaaffc57dd79d61dbf7e18b37ab49e0e4bc5f6"
