KV = "3.13.5"
PV = "${KV}"
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "a9c949fb84d771e13819b0886bd721e9"
SRC_URI[sha256sum] = "b20e4216120847dd4c0aeb161ce1e91bae940d05bc15f9a74bb6eb193085af96"
