KV = "3.13.5"
SRCDATE = "20151117"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "4528fa9dd5cbc005db063e6f8c578a41"
SRC_URI[sha256sum] = "979be15f3e027451c0f2becd838e69844768a9d6c765cefc7f4fa05d7c87f267"
