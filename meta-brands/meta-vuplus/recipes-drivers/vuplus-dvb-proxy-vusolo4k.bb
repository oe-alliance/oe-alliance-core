PV = "3.14.28"
KV = "${PV}-1.8"
SRCDATE = "20190424"
SRCDATE_PR = "r0"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "7185ff61b7a033336a75ea15a0ad1218"
SRC_URI[sha256sum] = "26aaf2b44f63b670719770d8350ca5aada1e1ef7e87ea514f5663450630c0443"
