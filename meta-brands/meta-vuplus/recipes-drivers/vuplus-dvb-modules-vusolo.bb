KV = "3.9.6"
SRCDATE = "20151117"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "b74daa1ec06de39ac4914b97b2290ff3"
SRC_URI[sha256sum] = "42f45304f010cabb26d5a2ded59dc365fad5dcfb910658af2c1b1d59159f8051"
