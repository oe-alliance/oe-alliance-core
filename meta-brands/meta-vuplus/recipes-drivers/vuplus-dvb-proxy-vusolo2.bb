KV = "3.13.5"
PV = "${KV}"
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "f36c5f1705a7e7a2de0074d3f861265c"
SRC_URI[sha256sum] = "98404f399d03175a09af170057747fe6d1390696da046bdc06e0707938349d18"
