KV = "3.9.6"
SRCDATE = "20151117"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "bm750"

SRC_URI[md5sum] = "c9b0bf87418118a4649f6b0205955bf7"
SRC_URI[sha256sum] = "ccaf77d424660da6cb735a3dc37698b1d56f5ede3679bb072aa4424a9e42d5a4"
