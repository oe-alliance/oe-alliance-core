PV = "4.1.20"
KV = "${PV}-1.9"
SRCDATE = "20210407"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "d10f5a25f3f01fffc4df2c9cfa4fb027"
SRC_URI[sha256sum] = "fa11a27d76578b2f017e55d8df1df6cf9024e178cdf5ab80d0905b78b15b8d8b"