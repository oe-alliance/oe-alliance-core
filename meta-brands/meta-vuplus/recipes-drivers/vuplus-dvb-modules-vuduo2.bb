KV = "3.13.5"
SRCDATE = "20151117"

require vuplus-dvb-modules.inc


SRC_URI[md5sum] = "0e5158ea5967d7416fcee2b2e0b83d68"
SRC_URI[sha256sum] = "1d853a35cdbb36544857353354ff9b1e5e55b4e1500f53bdec477b12f51bce0c"
