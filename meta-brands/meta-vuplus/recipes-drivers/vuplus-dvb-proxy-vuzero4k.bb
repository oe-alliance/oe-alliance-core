PV = "4.1.20"
KV = "${PV}-1.9"
SRCDATE = "20210407"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "f45b398fc6930d65bbf220719c10636a"
SRC_URI[sha256sum] = "2aafcc34ea1bd14ab6282dae5b9979d08ac64c84fe0f08a14bd63aef3cdbbe22"