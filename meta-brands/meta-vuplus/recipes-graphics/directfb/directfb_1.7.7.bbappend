FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

require directfb-${TARGET_ARCH}_1.7.7.inc

