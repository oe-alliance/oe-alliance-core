SRCDATE = "20180502"
SRCDATE_PR = "r1"
PV = "0.1.0"

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRC_URI[md5sum] = "9c2b313b2f926ceb07125d45cd6ea7b0"
SRC_URI[sha256sum] = "35eaf78a1977c24bea063469f7af4e6601f9f391ea5907aabb812640bda817e7"

require libvupl.inc
