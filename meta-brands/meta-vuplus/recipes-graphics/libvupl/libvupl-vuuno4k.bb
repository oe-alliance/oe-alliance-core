SRCDATE = "20180502"
SRCDATE_PR = "r1"
PV = "0.1.0"

COMPATIBLE_MACHINE = "^(vuuno4k)$"

SRC_URI[md5sum] = "d303e2cde6fff2753f42e872f3f6b7a5"
SRC_URI[sha256sum] = "62f617c53ef3617748f1c82d2fc0817688f7ea20f94ca0d8455e81295e3ad924"

require libvupl.inc
