SRCDATE = "20180502"
SRCDATE_PR = "r1"
PV = "0.1.0"

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRC_URI[md5sum] = "0aab764665b72c3a9b59292366f093d1"
SRC_URI[sha256sum] = "7988175b91dd2618d357fec09ced7515fdde802f6a063ccb34654daa75202736"

require libvupl.inc
