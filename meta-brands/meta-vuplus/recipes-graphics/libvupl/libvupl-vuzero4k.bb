SRCDATE = "20180502"
SRCDATE_PR = "r1"
PV = "0.1.0"

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRC_URI[md5sum] = "c4e1652310eb491a6e98197c3807219c"
SRC_URI[sha256sum] = "a4e5e5a748f240fa2b8f47d9f2266387094630d3f9c6f86981faa44e0ff52759"

require libvupl.inc
