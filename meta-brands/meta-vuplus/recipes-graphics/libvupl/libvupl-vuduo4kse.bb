PV = "0.1.0"
SRCDATE = "20200319"
SRCDATE_PR = "r1"

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRC_URI[md5sum] = "c799aa439f8a342b943f9936a9c4880c"
SRC_URI[sha256sum] = "b0d117cd5edbc0316984da45c0c0950cd31d3338e46105cf70ec3e243565d2cb"

require libvupl.inc
