SRCDATE = "20180502"
SRCDATE_PR = "r1"
PV = "0.1.0"

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRC_URI[md5sum] = "414fe23bdda4048b8aefdedabe08d536"
SRC_URI[sha256sum] = "b5fd20b31dfe2634bc0777318bbc93d9481283cb000c7508c75817e20956eb2d"

require libvupl.inc
