SRCDATE = "20180502"
SRCDATE_PR = "r1"
PV = "0.1.0"

COMPATIBLE_MACHINE = "^(vusolose)$"

SRC_URI[md5sum] = "70b140ac151902ba77fcfcc2f4a5bf1d"
SRC_URI[sha256sum] = "fb3ce11b99d0c31c92e61974a033f630a981ffc7f373b200af002dcccce27d14"

require libvupl.inc
