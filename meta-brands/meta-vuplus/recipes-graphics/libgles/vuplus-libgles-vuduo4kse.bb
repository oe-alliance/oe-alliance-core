require vuplus-libgles.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRCDATE = "20210527"
SRCDATE_PR = "r0"
PV="17.1"

S = "${WORKDIR}/libgles-vuduo4kse"

SRC_URI[md5sum] = "aa34e8f35104aa68e70bb5307e074021"
SRC_URI[sha256sum] = "b20224f50c25ac4c6710b3de490667143017ca3306c7d13d4fa476113feff1e9"
