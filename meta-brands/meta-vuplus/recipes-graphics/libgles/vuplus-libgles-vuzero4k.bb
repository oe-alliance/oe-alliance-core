require vuplus-libgles.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRCDATE = "20181204"
SRCDATE_PR = "r0"
PV="17.1"

SRC_URI[md5sum] = "e1c2d320e211053b435331d3767b8c0f"
SRC_URI[sha256sum] = "020496c3ab898f7637bb07203d798849ad852ae7fd56a8cdd4a9e4ef6f8cf7e0"
