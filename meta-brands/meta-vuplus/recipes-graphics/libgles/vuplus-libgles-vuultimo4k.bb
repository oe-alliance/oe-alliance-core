require vuplus-libgles.inc

SRCDATE = "20161130"
SRCDATE_PR = "r0"
PV="16.1"

SRC_URI[md5sum] = "7250b32ad74e1b3bf9b96b9c3cefc7be"
SRC_URI[sha256sum] = "1049373dac4f462330f2ea0401db26b095d4498b8b0b245af2a0490a5d0ef4bc"
