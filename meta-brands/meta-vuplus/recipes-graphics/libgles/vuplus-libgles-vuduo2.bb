SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-libgles.inc

SRC_URI[md5sum] = "32fae0e0ba480a7ed4e9cec1e4dcbd30"
SRC_URI[sha256sum] = "7f72cc53dbd2bf68039f87d98f2b956e98c6f31e0d807a8b8f2486bbb23fbfa6"
