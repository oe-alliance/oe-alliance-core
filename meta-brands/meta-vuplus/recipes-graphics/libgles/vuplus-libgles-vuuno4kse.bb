require vuplus-libgles.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRCDATE = "20181204"
SRCDATE_PR = "r0"
PV="17.1"

SRC_URI[md5sum] = "cbc6081b28d741a4108d3f7c8177744e"
SRC_URI[sha256sum] = "6aa9c3fb2017afab6a9493edf56fc6eea0a75a52424c729781c999caf41b1339"
