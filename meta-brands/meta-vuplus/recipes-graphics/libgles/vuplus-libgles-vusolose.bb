SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-libgles.inc

SRC_URI[md5sum] = "04798053b8617994b757448494816d17"
SRC_URI[sha256sum] = "03a71561a368243587d2ca9cc8d605c438b1e7d7e87feda7c1f141608f437ff9"
