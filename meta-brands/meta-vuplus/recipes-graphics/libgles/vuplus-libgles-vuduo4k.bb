require vuplus-libgles.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20181204"
SRCDATE_PR = "r0"
PV="18.1"

S = "${WORKDIR}/libgles-vuduo4k"

SRC_URI[md5sum] = "34981842d0435ff5edfff93a21a3a005"
SRC_URI[sha256sum] = "76931e18832c6661f199bf4b4728421af0871c5d3d6db4677ffe7d0cd2b7984b"
