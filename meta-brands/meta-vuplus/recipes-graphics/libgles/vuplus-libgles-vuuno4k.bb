require vuplus-libgles.inc

SRCDATE = "20161202"
SRCDATE_PR = "r0"
PV="16.1"

SRC_URI[md5sum] = "cc448b59d07f7d5b01ecf12b40d3eda8"
SRC_URI[sha256sum] = "74678d8cf5e387cf6651cf0496224bf58309bf03c13c772e6ab6405d6b3e8a4d"
