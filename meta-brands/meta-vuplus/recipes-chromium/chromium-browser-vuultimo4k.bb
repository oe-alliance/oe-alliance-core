SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "5c9a3b98044fbcf947a59dff0f6dbf3d"
SRC_URI[sha256sum] = "fea909ebb8654f99b189b6c4ed544d3572071ea96939b31e89a0ed5c9f1cc63c"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"
