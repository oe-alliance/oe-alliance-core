SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "e24e517a80d6e59cc769e1fa6328f69e"
SRC_URI[sha256sum] = "9d8ed2d656308ae6104a3bb9b621a7eb864917762568fb34f234345a7d7a0c88"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"
