SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "005ea1775e43dc6d11385bef8dba5710"
SRC_URI[sha256sum] = "5dd676fa656c7516ae5e56b7099ea3a1b418422b76b1698676806349578d9e66"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"
