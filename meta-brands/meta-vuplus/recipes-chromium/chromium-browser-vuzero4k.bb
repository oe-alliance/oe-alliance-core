SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "86482047cf0f6f9b88c09bf67242c062"
SRC_URI[sha256sum] = "b627790f49d5e7fbc5d281f862a9fec68a40b04b79191c621d2843bde7c84605"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"
