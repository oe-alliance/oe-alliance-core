SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "3ca7d2370d267d78ca14e0037a785ed0"
SRC_URI[sha256sum] = "288d098ae60eabbb5c7421d931e1e1378c966831e9ae8976f7af0b4a10869981"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"
