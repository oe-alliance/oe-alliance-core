SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "761f1cb676013dc6528cf222ec18cd27"
SRC_URI[sha256sum] = "36c6a9812bc23c763de52f75a82ce1f35a6095443cb2081abfca0c99210f3661"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"
