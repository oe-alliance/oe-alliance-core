SRCDATE = "20201020_r1"
SRC_URI[md5sum] = "0797afa0edf2f37ad4f11331df6458e9"
SRC_URI[sha256sum] = "a559497a3fdbefd655c240e77955a6e97016140e2d5ec29e6901646fa6786ad9"

require chromium-browser.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"
