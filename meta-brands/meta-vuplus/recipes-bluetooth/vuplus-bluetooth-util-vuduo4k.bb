require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20181109"
SRCDATE_PR = "r1"

SRC_URI[md5sum] = "fbbe1050ab72d8ae1b541293eb83a9d6"
SRC_URI[sha256sum] = "c99de55349d9d8259639a70154956583aa29e1d28517de883d8811934d8bd6b8"
