require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

FIRMWARE_PATH="bcm43569"
FIRMWARE_FILE="BCM43569A2_001.003.004.0060.0109.hcd"

SRCDATE = "20161115"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "411c213563c690aa46da8f7d45426e2c"
SRC_URI[sha256sum] = "a871ca49a28302cdb461839497ab9e0a1623f9f9a647e39cc827d26363714110"

