COMPATIBLE_MACHINE = "^(vuzero)$"

SRCDATE = "20180820.r2"

SRC_URI[md5sum] = "bdef7b310695e03bcff42805d47b5ef3"
SRC_URI[sha256sum] = "1d2636493bea2394380baedd9dcf33a94b492d73ab3b86d3c72063248e401451"

require vuplus-stalkerclient.inc
