COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRCDATE = "20180820.r2"

SRC_URI[md5sum] = "950ed0295488a1ba1a7af6f67873abb4"
SRC_URI[sha256sum] = "a24de6eeb99903ad9013c6a28afb6c198c2bde7b16c7cc2effae94d93bf3885f"

require vuplus-stalkerclient.inc
