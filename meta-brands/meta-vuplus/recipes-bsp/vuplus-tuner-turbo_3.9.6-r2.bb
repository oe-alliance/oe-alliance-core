require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vusolo)$"

KV = "3.9.6_R2"

SRCDATE = "20150303"

SRC_URI[driver.md5sum] = "445b120a3a290719fbfc7e97c0a41e0d"
SRC_URI[driver.sha256sum] = "3f872235f5aa379c8122349e4fa3058bcd61790fbdf8a45f419c27e69de3f150"
