require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vuuno4kse|vuzero4k)$"

KV = "4.1.20-1.5"

SRCDATE_arm = "20171013"

SRC_URI[driver.md5sum] = "cacd4179f26acab9950fbc97a7eaab49"
SRC_URI[driver.sha256sum] = "fa68af0f0c114b8e2bc14ca0ff83266e9e7e1d704702563304b923faf0150873"
