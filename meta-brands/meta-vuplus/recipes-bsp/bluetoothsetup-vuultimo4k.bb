require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRCDATE = "20170906"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "0a53f31ed5d9ba6ea55a94b1e842df22"
SRC_URI[sha256sum] = "786002cb6cde2db238c7f7ae2cf4738bff4c67a772f5eb3cdffdb95902f7fa73"
