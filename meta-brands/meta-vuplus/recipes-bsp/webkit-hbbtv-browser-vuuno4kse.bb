SRCDATE = "20171114.r0"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"


SRC_URI[md5sum] = "97275ff1d7aedd9b847bcb76df5559bb"
SRC_URI[sha256sum] = "eff60a3ae0c077cb34dc3818643234c729e91fb49e685bf6efcd07fc0dced754"
