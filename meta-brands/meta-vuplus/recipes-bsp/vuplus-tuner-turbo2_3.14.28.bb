require vuplus-tuner-turbo2.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRCDATE_arm = "20201207"

KV = "3.14.28"

SRC_URI[driver.md5sum] = "6c90c20f8f8bd811ebece927ce7d6698"
SRC_URI[driver.sha256sum] = "eaf4949e4422339f879ab8093fdc714e61001d423e8016aa67871bcad8eb068f"

