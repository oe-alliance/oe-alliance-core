SRCDATE = "20151117"
SRCDATE_PR = "r0"
PV="15.1"

require vuplus-platform-util.inc

SRC_URI[md5sum] = "34b974d67cf9e878679d8f226d5d12d1"
SRC_URI[sha256sum] = "5dff4c768654070f5787e167583082e67c2799571e58dc46bab35e51235102b4"
