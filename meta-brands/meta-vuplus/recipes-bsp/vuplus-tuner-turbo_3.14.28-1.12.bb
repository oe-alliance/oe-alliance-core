require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vuultimo4k|vuuno4k)$"

KV = "3.14.28-1.12"

SRCDATE_arm = "20161020"

SRC_URI[driver.md5sum] = "a1ba2928f2be2f70daaeb2112b3bf462"
SRC_URI[driver.sha256sum] = "6b73a5102c4491085359af3b26f8088b7553edfc007d29059af456fe68ed6207"
