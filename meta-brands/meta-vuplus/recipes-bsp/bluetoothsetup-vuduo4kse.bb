require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRCDATE = "20200320"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "ee90c784d3a0b050e66ee81624fcb631"
SRC_URI[sha256sum] = "e079638b1ff6d5d1cbea86ec336eb85ff2e33e1cacd6e1acac97520b8568ecd7"
