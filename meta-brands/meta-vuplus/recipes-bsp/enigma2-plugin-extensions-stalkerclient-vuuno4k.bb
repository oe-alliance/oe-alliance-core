COMPATIBLE_MACHINE = "^(vuuno4k)$"

SRCDATE = "20180820.r2"

SRC_URI[md5sum] = "fe604b6a5ea7aa813177a76dceaada3f"
SRC_URI[sha256sum] = "0f49915d2536a4056233171cbe0031720d843751eed624de2a599f981dbe6c7b"

require vuplus-stalkerclient.inc
