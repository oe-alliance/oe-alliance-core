require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

PV="17.1"
SRCDATE = "20181204"
SRCDATE_PR = "r0"

S="${WORKDIR}/platform-util-vuzero4k"

SRC_URI[md5sum] = "078d74102522213fa1df495a32d46013"
SRC_URI[sha256sum] = "4d0432ebdd67225b7f7e5d2aae64449df40341da6769901920e9023bf4843a9d"
