require vuplus-tuner-turbo2.inc

COMPATIBLE_MACHINE = "^(vuuno4kse|vuzero4k)$"

KV = "4.1.20-1.5"

SRCDATE_arm = "20201207"

SRC_URI[driver.md5sum] = "767d0446906251beef3d47441ea6d03f"
SRC_URI[driver.sha256sum] = "41f276b048380dfbd20834aa3a80a58d82fff8f73d151e88d6396189ff60b967"

