require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRCDATE = "20171114"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "462f37c6852b57d88a81b0cb1497acd5"
SRC_URI[sha256sum] = "f924e70ea45fbdd006523fd3bf5cdae50894039d9c1d95ecac8a5591d32ef6ad"
