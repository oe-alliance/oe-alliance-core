PR_append = ".0"

CFLAGS_vusolo4k += " -fstack-protector-all "
CXXFLAGS_vusolo4k += " -fstack-protector-all "

