SRCDATE = "20200319.r1"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRC_URI[md5sum] = "dbcaeaf818d7def0806901eba3cbd813"
SRC_URI[sha256sum] = "b98209f3fffa1433396c9262ade45c54e5a6b7fa1f527b40d2acb89ff3e0416d"
