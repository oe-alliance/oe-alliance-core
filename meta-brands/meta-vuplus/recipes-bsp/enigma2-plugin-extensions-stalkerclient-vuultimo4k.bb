COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRCDATE = "20180820.r2"

SRC_URI[md5sum] = "b3b9f9fdbb92ce499a8aecf6c7049cd1"
SRC_URI[sha256sum] = "468e82cde62241b90af59fefa15e6a9d37d144ac4db9adbf99db2bfe02de95af"

require vuplus-stalkerclient.inc

