COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRCDATE = "20180820.r2"

SRC_URI[md5sum] = "68e82663f65efb43505faa3446d0988d"
SRC_URI[sha256sum] = "45f31e3bc785f649c693899c1379f93735b01cc6588722d68789f9c4c8b901f6"

require vuplus-stalkerclient.inc

