SRCDATE = "20151117"
SRCDATE_PR = "r0"
PV="15.1"

require vuplus-platform-util.inc

SRC_URI[md5sum] = "05af480d2dfded16c98142d86401228a"
SRC_URI[sha256sum] = "b1eb2b430a7ecfa601d254f0b0068006850274f2945f7804d8f1602453ee30ae"
