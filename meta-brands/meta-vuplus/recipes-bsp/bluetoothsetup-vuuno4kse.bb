require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRCDATE = "20170906"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "379c605711ad2c4e23c3aa078de80855"
SRC_URI[sha256sum] = "b11cf6dc5fc3b911fc8f0056394fa08bbf2ec079c83e7afa40e87d83701583a7"
