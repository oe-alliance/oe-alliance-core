SRCDATE = "20161018.r0"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"


SRC_URI[md5sum] = "9eb98848424720f6e6c97a4253230fd5"
SRC_URI[sha256sum] = "66580fc3e8d5cd8971577fd333c0cdb29169ceccd44b37e27a5ed79660994adf"
