require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vusolo2|vuduo2|vusolose|vuzero)$"

SRCDATE = "20150303"

KV = "3.13.5"

SRC_URI[driver.md5sum] = "93a2fcb1445c16091eb2517cf4d06a00"
SRC_URI[driver.sha256sum] = "c35bacdaafd522f9fc07f51c0f016a48371457d9175c33ce1b3cd4c607c51174"
