require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRCDATE = "20171114"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "691e7ecc30d3bce4653f4f2bbb877e48"
SRC_URI[sha256sum] = "3ad45f205b7c4541b07c6d8ce3e5fe1de1f4ca17e223dea948d87581a6722317"
