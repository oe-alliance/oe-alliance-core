COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRCDATE = "20200924.r1"

SRC_URI[md5sum] = "ddedaf57dbe1a0a78940f39d467cd2b6"
SRC_URI[sha256sum] = "a5b58b576fafc45e98a3bc451efcbf3894ed19da9cc9287aced2773cf41ed89a"

require vuplus-stalkerclient.inc

