require vuplus-tuner-turbo2.inc

COMPATIBLE_MACHINE = "^(vuduo4k|vuduo4kse)$"

KV = "4.1.45-1.17"

SRCDATE_arm = "20201207"

SRC_URI[driver.md5sum] = "ff1b2fca6f88c8640875a22e1780cae3"
SRC_URI[driver.sha256sum] = "eee4c5ce7a63bfdc751e07041506021db8617228ce5e58e139bbf784eb53c84e"

