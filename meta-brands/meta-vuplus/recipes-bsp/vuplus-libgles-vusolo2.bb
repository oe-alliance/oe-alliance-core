SRCDATE = "20150113"
SRCDATE_PR = "r0"

require vuplus-libgles.inc

SRC_URI[md5sum] = "86f073e739326fc49d0bddcda9ff6cd0"
SRC_URI[sha256sum] = "6e105eb10fcfbd38248f4ce91a0c105274a10a1aed8cc5c71a797fabeb377744"
