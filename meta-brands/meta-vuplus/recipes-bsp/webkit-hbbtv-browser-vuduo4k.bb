SRCDATE = "20181010.r4"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"


SRC_URI[md5sum] = "d0f7ed2f854fb6b014917ea314ad8d86"
SRC_URI[sha256sum] = "f0f62147155f34184682549037c0e2f796b6bdb9b8e1e86c94becad827b5fbe1"
