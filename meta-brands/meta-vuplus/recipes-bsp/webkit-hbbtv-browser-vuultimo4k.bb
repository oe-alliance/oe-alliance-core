SRCDATE = "20161018.r0"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"


SRC_URI[md5sum] = "ae069cbbfeafb228f58374a17e9c1ef9"
SRC_URI[sha256sum] = "3171a57a2c2abc80aaaca9dd52fdaa6fe549008feadb04975dab476fc8674a02"
