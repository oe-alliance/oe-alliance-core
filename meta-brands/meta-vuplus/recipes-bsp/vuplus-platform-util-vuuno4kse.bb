require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

PV="17.1"
SRCDATE = "20181005"
SRCDATE_PR = "r0"

S="${WORKDIR}/platform-util-vuuno4kse"

SRC_URI[md5sum] = "6c348b48c845f7f7b27ec3f4a9a3eeb3"
SRC_URI[sha256sum] = "ecf58555b07b76857f63d4c5a4fdefd12fcd69f70d657eee4aa740e63eb15ec1"
