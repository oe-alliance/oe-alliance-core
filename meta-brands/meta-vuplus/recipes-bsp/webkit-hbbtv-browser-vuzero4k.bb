SRCDATE = "20180213.r1"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"


SRC_URI[md5sum] = "aac7a3d89ba501b735055a3902472a17"
SRC_URI[sha256sum] = "2bbdb3252ca38e8b4be25f1c51363530f75563a928da5d01bc8b4069913b0ad0"
