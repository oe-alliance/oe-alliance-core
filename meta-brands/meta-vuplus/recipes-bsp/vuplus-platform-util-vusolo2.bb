SRCDATE = "20161130"
SRCDATE_PR = "r1"
PV="15.1"

require vuplus-platform-util.inc

SRC_URI[md5sum] = "77535e227a9100d7bedae9734e09b9e1"
SRC_URI[sha256sum] = "94c59d71f09f04fefdce7f4440e2fa33d009a88adc930d2737404ef0a91cf48c"
