COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRCDATE = "20180820.r2"

SRC_URI[md5sum] = "23a1ba5cffedc4cf425fdfd6f09f0b55"
SRC_URI[sha256sum] = "4fd838608eb62723afbee09f2d74e3c24ff842237cd8e9a16a9cdd3c5027ec1c"

require vuplus-stalkerclient.inc
