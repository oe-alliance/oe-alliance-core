require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

PV="16.1"
SRCDATE = "20161125"
SRCDATE_PR = "r0"

S="${WORKDIR}/platform-util-vuuno4k"

SRC_URI[md5sum] = "1f93824d713458def46bef3bc4ad13d2"
SRC_URI[sha256sum] = "3aa2eab628e23b78d4a9bc224394b208e17b31bd41b0955ec41e1252f0677f2c"
