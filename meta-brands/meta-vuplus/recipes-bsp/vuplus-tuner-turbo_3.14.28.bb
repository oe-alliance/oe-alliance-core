require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRCDATE_arm = "20151104"

KV = "3.14.28"

SRC_URI[driver.md5sum] = "3e707eaa7c87db766dee51bdc1b057f0"
SRC_URI[driver.sha256sum] = "0d0e417ac57547ee5cd29f42702866bae3e5c204e2d889384407a4150e14039f"
