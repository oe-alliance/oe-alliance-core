SRCDATE = "20150302"
SRCDATE_PR = "r0"

require vuplus-libgles.inc

SRC_URI[md5sum] = "c6c8882d4fe1958e5f1fab3ba254a583"
SRC_URI[sha256sum] = "3900237115e5de8c2365b6151f82bb340598d4ce6c473bda3b8e79a3ebf74e64"
