require vuplus-tuner-turbo2.inc

COMPATIBLE_MACHINE = "^(vusolo2|vuduo2|vusolose|vuzero)$"

SRCDATE = "20210205"
FW_SRCDATE = "20210205"

KV = "3.13.5"

SRC_URI[binfw.md5sum] = "41bfacbe2fd2772c92e4e32c4662b73e"
SRC_URI[binfw.sha256sum] = "85540afb31966978cafe765b304e66f1b7496fc656facf12d6da3eb2cad69093"
SRC_URI[driver.md5sum] = "a414132e63766326be817f40ceb5f907"
SRC_URI[driver.sha256sum] = "514967476ac33252a3adb0ea793e7c57002e17393bf92be75c27c969928db592"

