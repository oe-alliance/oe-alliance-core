require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vuduo|vuuno|vuultimo)$"

KV = "3.9.6_R1"

SRCDATE = "20150303"

SRC_URI[driver.md5sum] = "3e85268a9cdc8379564e4e8a7a6ff035"
SRC_URI[driver.sha256sum] = "1314df03abd7e9eb9a11be7ddbb9c67e1ac4be3dd658efd75b137bc08754315c"
