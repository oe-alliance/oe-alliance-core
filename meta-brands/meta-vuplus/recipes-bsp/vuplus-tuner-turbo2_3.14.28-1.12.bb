require vuplus-tuner-turbo2.inc

COMPATIBLE_MACHINE = "^(vuultimo4k|vuuno4k)$"

KV = "3.14.28-1.12"

SRCDATE_arm = "20201207"

SRC_URI[driver.md5sum] = "a547314d5d9b2b307f8be0587cf01019"
SRC_URI[driver.sha256sum] = "eb2d5c765b5ae41d929dcd87b28e57b6d4d4559e43dfbefbbdf3d8e7da4c4099"

