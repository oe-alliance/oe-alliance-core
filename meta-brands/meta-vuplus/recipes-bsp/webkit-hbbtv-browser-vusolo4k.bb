SRCDATE = "20151228.r0"

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"


SRC_URI[md5sum] = "507cf22f00847285bb3ce186bedbbdcc"
SRC_URI[sha256sum] = "648b7c088305e9e806f76230deab85258ab0888249b2c13b6d9d8149fe19d454"
