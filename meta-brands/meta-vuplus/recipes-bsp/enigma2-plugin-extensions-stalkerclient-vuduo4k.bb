COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20200924.r1"

SRC_URI[md5sum] = "43c28995bc503c05026e1156001808a2"
SRC_URI[sha256sum] = "08ccc5dba147af35b976c221337f884329a561f0badb6851171c1ca4634c7e40"

require vuplus-stalkerclient.inc
