SRCDATE = "20150302"
SRCDATE_PR = "r0"

require vuplus-libgles.inc

SRC_URI[md5sum] = "71ebcdea71e178ea9e754e0912a0a941"
SRC_URI[sha256sum] = "ed7d446b51e8cbb088d76b9dfc185a7b9dc67d63d79be204a6c4b09df0090c8c"
