require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

PV="16.1"
SRCDATE = "20161215"
SRCDATE_PR = "r0"

S="${WORKDIR}/platform-util-vuultimo4k"

SRC_URI[md5sum] = "2845b16326deaac5cabbe4a4c3762c3b"
SRC_URI[sha256sum] = "0ff3c643e1d77eb2470b6381466bf52ca8c29f0813ee5b5934d0a45f85664149"
