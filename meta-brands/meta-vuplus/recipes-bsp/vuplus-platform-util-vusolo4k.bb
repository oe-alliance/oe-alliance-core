SRCDATE = "20151104"
SRCDATE_PR = "r0"
PV="15.2"

require vuplus-platform-util.inc

SRC_URI[md5sum] = "c95c861ac49de40cf75e6683832d0049"
SRC_URI[sha256sum] = "295a039f52027eb63703e816ba810c2f2273afbb9b94ac4caadee50e20bfa23e"
