require kodiegl.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

PV = "1.0"
PR_append = ".r0"

PKGDATE="20190124p1"
SRC_URI[md5sum]="ad922af7fc9f9615aac1f87d65b013b0"
SRC_URI[sha256sum]="f20dc1ab8f7c50379b6eccda428b06bebc84ce695786c67a0909624a32b6743c"
