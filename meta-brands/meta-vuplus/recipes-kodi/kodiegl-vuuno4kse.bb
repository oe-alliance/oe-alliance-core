require kodiegl.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

PV = "1.0"
PR_append = ".r0"
 
PKGDATE="20190124p1"
SRC_URI[md5sum]="10b6be8ee355ecc6f7c4a8f9971aed60"
SRC_URI[sha256sum]="d9cd78decfa27b86c74e76a4fa3bd3c8bc4b8f8611ebb520665e5e06ec031ce7"
