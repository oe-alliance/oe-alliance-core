require kodiegl.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

PV = "1.0"
PR_append = ".r1"

PKGDATE="20181111p1"
SRC_URI[md5sum]="a88c7f2472a7b7ccc8576d4070622346"
SRC_URI[sha256sum]="d99d5c5f222ec9dc73c223228b193b7de04596f0e30ffb60a8fb2c5e7a1f5567"

