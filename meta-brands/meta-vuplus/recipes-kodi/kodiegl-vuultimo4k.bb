require kodiegl.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

PV = "1.0"
PR_append = ".r0"

PKGDATE="20190124p1"
SRC_URI[md5sum]="815bb54f607682d9cc56f0545ecf072a"
SRC_URI[sha256sum]="561428e13cddad20c70fc352a354227d6dee58a50d11fa5b9f90130e554d4f61"
