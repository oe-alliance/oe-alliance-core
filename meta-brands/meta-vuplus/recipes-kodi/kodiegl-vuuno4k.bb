require kodiegl.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

PV = "1.0"
PR_append = ".r0"

PKGDATE="20190124p1"
SRC_URI[md5sum]="5d331f9a7b13dd21a6979a25bf4c8e88"
SRC_URI[sha256sum]="14f10216502e46a38e79c3059a8f28da28181f69958348626caca90c0a3be7cd"
