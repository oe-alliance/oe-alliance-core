require recipes-mediacenter/kodi/stb-kodi_${PV}.bb
require stb-kodi-vu7376.inc
