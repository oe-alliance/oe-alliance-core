require kodiegl.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

PV = "1.0"
PR_append = ".r0"

PKGDATE="20200319p3"
SRC_URI[md5sum]="80ff4067b01e0d9caa92cccfd63a05b8"
SRC_URI[sha256sum]="d013e5996144644bd398242b837f4a3032cbf1c417b2cde5381aef906bcd1d72"
