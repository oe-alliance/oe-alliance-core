require kodiegl.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

PV = "1.0"
PR_append = ".r0"
 
PKGDATE="20190124p1"
SRC_URI[md5sum]="cc7a9e4aa0805e69f47f815dd06ff4c0"
SRC_URI[sha256sum]="0a13ee99934fa6d4852a1e5b2fd2d9cdbd668fe2f92688ed43336d176a73dbc0"
