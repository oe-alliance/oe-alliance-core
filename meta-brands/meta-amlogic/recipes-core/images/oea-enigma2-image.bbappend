inherit_defer ${@d.getVar("GTX_IMAGE_CLASS") or ""}
