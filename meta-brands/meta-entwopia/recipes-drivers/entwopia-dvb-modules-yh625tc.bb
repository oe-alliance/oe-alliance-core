KV = "4.10.6"
SRCDATE = "20180818"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "69d220787675daa6a64ea04fc29e0ca6"
SRC_URI[sha256sum] = "c9440cbceb3657b5ae7bb61ff494be3268510f5fe356521be063e6a1e1d17b41"
