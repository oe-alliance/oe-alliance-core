KV = "4.10.6"
SRCDATE = "20180818"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "18edc843829324f0d4602da72c5af66b"
SRC_URI[sha256sum] = "2fff48a925537de8fe7716f5ae4db63eb9a002ed0e4ba40fd355b83e9e3ef1fd"
