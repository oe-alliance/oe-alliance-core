KV = "3.14.2"
SRCDATE = "20160302"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "5f476b18aba6f2bdd7cfccd630465ab9"
SRC_URI[sha256sum] = "27396e2bd386f987c0eb8c3a7feae05141819e13a38f972b1ac7523db46573e5"
