KV = "3.14.2"
SRCDATE = "20161212"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "1023fe94291f6bb81494da9818bce52b"
SRC_URI[sha256sum] = "f0686240c454a6da02aa6224dfb40e5c9b347a9be31bb6aa391f6dfd56f84814"
