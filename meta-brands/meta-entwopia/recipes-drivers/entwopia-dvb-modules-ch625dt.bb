KV = "4.10.6"
SRCDATE = "20180818"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "aa691db07022fcadf4046f73183a9310"
SRC_URI[sha256sum] = "80d5fb9b8c337c3d13e5777380e31e7747176f89a1fe723dc37b231959bf40b8"
