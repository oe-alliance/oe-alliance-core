KV = "4.10.6"
SRCDATE = "20180818"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "39ffb5957e75357eea0bab602d7c3ab4"
SRC_URI[sha256sum] = "8c7f94c29ed6f00003a847ed9035fd341d2d173eb9ec2ced2f7ce6253ca4d6a1"
