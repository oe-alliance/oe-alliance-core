KV = "4.0.1"
SRCDATE = "20161104"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "41ae31b8237c7c6d2961a792aa319cdc"
SRC_URI[sha256sum] = "15e789c9052c1b22c4fefa11b033759c69bdfe9f6c2e184e203c77874c73549f"
