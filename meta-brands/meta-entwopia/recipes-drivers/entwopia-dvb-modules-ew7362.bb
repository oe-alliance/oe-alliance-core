KV = "3.14.2"
SRCDATE = "20161130"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "88a230061c002104aa8c3e42d7e0121b"
SRC_URI[sha256sum] = "d72e8e0d48c54e0b08b14e7c48f5c105eca5352d914954542d6698a996874f4b"
