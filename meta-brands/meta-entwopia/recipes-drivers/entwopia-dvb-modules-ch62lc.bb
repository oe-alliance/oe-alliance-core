KV = "3.14.2"
SRCDATE = "20160302"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "d46b232ff6de2475d705211d4550c6be"
SRC_URI[sha256sum] = "574a0f31113e8a37e7693087683bc25e1994640eaee1ba549d20fa772aee6020"
