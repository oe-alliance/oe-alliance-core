require anadol-buildimage_${PV}.bb
inherit native
