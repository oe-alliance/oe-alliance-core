KV = "3.18.18"
SRCDATE = "20150730"

require odin-dvb-modules.inc

SRC_URI = "http://source.mynonpublic.com/download/odinm7-drivers-${KV}-${SRCDATE}.zip"

SRC_URI[md5sum] = "ecbe6d9884accae8abc98906dfa7f1d1"
SRC_URI[sha256sum] = "0a24d5b8307f8a4f5861959efa9ed5e1d1795d5e25c0ef0f5a349fc8968961b4"
