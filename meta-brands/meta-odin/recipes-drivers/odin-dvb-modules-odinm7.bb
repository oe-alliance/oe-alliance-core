KV = "3.18.18"
SRCDATE = "20151021"

require odin-dvb-modules.inc

SRC_URI = "http://source.mynonpublic.com/download/odinm7-drivers-${KV}-${SRCDATE}.zip"

SRC_URI[md5sum] = "9a1e5484724ef8fbd39ed417d1180936"
SRC_URI[sha256sum] = "f96d6ff0bf3922d964d08dadd5a59d76411fd8753f1a251f749ef562a70978c2"
