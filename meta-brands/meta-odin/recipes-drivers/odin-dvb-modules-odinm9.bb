KV = "3.6.0"
SRCDATE = "20160514"

require odin-dvb-modules.inc

SRC_URI = "http://source.mynonpublic.com/download/${MACHINE}-drivers-${KV}-${SRCDATE}.zip"

SRC_URI[md5sum] = "7f31f1818d4f27a7669cfa476acb2acc"
SRC_URI[sha256sum] = "7fbd3ca5c334a8d2662b9d3fa3abe580db2d0c277ab6e1cbe443a88a8bf6e59c"
