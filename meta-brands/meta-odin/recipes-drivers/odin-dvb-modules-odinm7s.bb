KV = "3.18.18"
SRCDATE = "20150723"

require odin-dvb-modules.inc

SRC_URI = "http://source.mynonpublic.com/download/odinm7-drivers-${KV}-${SRCDATE}.zip"

SRC_URI[md5sum] = "ba21e246d2fa5bcd18667cd6efa89230"
SRC_URI[sha256sum] = "4922ae5e053dc96c970b5edb5a808e57703c6213180c8421896a7540c02f2451"
