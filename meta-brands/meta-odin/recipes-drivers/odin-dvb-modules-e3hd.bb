KV = "3.18.18"
SRCDATE = "20151021"

require odin-dvb-modules.inc

SRC_URI = "http://source.mynonpublic.com/download/${MACHINE}-drivers-${KV}-${SRCDATE}.zip"

SRC_URI[md5sum] = "2f5ade6f94b1b3d81cd74f0c156eb4fe"
SRC_URI[sha256sum] = "cf7007e2ef5a7698fe43f9eb8e0a0e9687af0179a8b0361b1b72b60ca1459ab7"
