KV = "3.14.2"
SRCDATE = "20140801"

SRC_URI[md5sum] = "40d6235b1da438c45fa8eab67fd550c5"
SRC_URI[sha256sum] = "a8f4e7609cf563bc68c05bda9df3ba0a46a7464760650e0701fa597fcfb109fd"

SRC_URI = "http://code-ini.com/software/drivers/ini-2000-drivers-${KV}-${SRCDATE}.zip"

require ini-dvb-modules.inc

