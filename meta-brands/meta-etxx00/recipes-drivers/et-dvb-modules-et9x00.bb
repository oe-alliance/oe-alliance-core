KV = "3.8.7"
SRCDATE = "20130524"

RDEPENDS_${PN} += "et-fpupdate-${MACHINE}"

require et-dvb-modules.inc

SRC_URI[md5sum] = "4a4b303b3b913f0ee64f52afc4a60be7"
SRC_URI[sha256sum] = "f6b59f464b70406b95a5dd8cb2e6260b57d11d5568009586163849c7e9091773"
