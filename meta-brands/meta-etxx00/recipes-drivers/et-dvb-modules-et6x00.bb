KV = "3.8.7"
SRCDATE = "20130524"

RDEPENDS_${PN} += "et-fpupdate-${MACHINE}"

require et-dvb-modules.inc

SRC_URI[md5sum] = "50c88a159554e8b27b77ca107138058b"
SRC_URI[sha256sum] = "3d3393ef2198fe61b74f242f9985e58480bcebaaf988b63922404ab34d0bdba3"
