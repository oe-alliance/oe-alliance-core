KV = "3.8.7"
SRCDATE = "20130807"

require et-dvb-modules.inc

SRC_URI[md5sum] = "2794f8f90d70990369767b89f3413452"
SRC_URI[sha256sum] = "d78e0f091e1d12d2b917b80ef30dd95dd1a22991582452760ed8bc5adbc61075"
