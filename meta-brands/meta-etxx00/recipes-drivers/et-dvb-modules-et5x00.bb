KV = "3.8.7"
SRCDATE = "20130524"

RDEPENDS_${PN} += "et-fpupdate-${MACHINE}"

require et-dvb-modules.inc

SRC_URI[md5sum] = "9484c04de33c2eb5bc71460d7db4aaa9"
SRC_URI[sha256sum] = "11e96ca1aaecab16592b6d3d2a47baf9150f8cfb3717675e96c0168f00a09e02"
