SRCDATE = "20170927"
SRCDATE_PR = "r0"
PV="16.2"

require platform-util.inc

SRC_URI[md5sum] = "78cbad4ca2e87dc27e278df02c7685f6"
SRC_URI[sha256sum] = "4c7d891219972dd7ab871fe57bb1d6c6c4ee7e72216c81926922c669d67be7a0"