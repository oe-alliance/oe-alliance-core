KV = "4.1.37"
GCCREV = "6.3.0"
SRCDATE = "20170918"

require et-dvb-modules-kodi.inc

SRC_URI[md5sum] = "f587511adddb8d628db89330ae0d3f7f"
SRC_URI[sha256sum] = "4f03e3e7760b2f6c0132e1b3c3182162f36c51e40d3c981f77458e2d40048252"
