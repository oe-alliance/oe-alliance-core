FPVERSION = "15"

require et-fpupdate-1.0.inc

SRC_URI[avrmain.md5sum]  = "8e93eec9ffbcf9a8f0abb2061db12cb4"
SRC_URI[avrmain.sha256sum] = "b06ad114e1d2bf52f4dd924db12f29fc297fa574f5abaa45429a8c0c3a6244a3"
