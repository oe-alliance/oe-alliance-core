FPVERSION = "15"

require et-fpupdate-1.0.inc

SRC_URI[avrmain.md5sum] = "49a87ef47888207b8a9128431e5bcc48"
SRC_URI[avrmain.sha256sum] = "19ab87571905520988338ceca3b20a3cfcb924723f5c84d325c644830ab7ad3f"
