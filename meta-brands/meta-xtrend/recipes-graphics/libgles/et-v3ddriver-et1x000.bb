SRCDATE = "20170918"

require et-v3ddriver.inc

SRC_URI[md5sum] = "30bc3774519540e1c88a941ffbb3b209"
SRC_URI[sha256sum] = "e9a9b8fc8615e193e0c2c14b286fff7719276c7a50f9614b57251c0b74959972"

COMPATIBLE_MACHINE = "et1x000"
