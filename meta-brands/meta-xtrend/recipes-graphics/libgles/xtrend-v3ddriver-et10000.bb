SRCDATE = "20170322"

require xtrend-v3ddriver.inc

SRC_URI[md5sum] = "348d1a7f8b3244119ade255042c216ea"
SRC_URI[sha256sum] = "584847098725551adafe2f1745d0d1d9b990333e41a94268d26878cf563493ba"

COMPATIBLE_MACHINE = "et10000"
