require amiko-buildimage_${PV}.bb
inherit native
