KV = "4.4.35"
SRCDATE = "20190415"

require amiko-dvb-modules-hisi.inc

SRC_URI[md5sum] = "1bdf9b4ec73807e0029fe51375ff5f6a"
SRC_URI[sha256sum] = "0df0eb6348909279883520be50d78881c98e75d211754577757dc0ab763d383d"
