SRCDATE = "20190415"

require amiko-libs.inc

SRC_URI[md5sum] = "b12164460fa99416f69ce78a2645f888"
SRC_URI[sha256sum] = "56846c673914d0c70ba5098d2e2b3d25737b56f2531a51f2f4344d2f499a0d56"
