require clap-buildimage_${PV}.bb
inherit native
