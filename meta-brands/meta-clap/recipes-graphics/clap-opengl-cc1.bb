SRCDATE = "20180301"

SRC_URI[md5sum] = "faf96419cc542a5fe0df49fd2914a7ad"
SRC_URI[sha256sum] = "7614f03c1db3641ea8793c28fcfdaa74cf45a31f89a7df14114b522fb5576d6e"

require clap-opengl.inc
