SRCDATE = "20180910"

require clap-libs.inc

SRC_URI[md5sum] = "318f6d353f55131ba8bbadf4d25a0c70"
SRC_URI[sha256sum] = "062a8447ae0df19e738f75746bce5aa2d90ace8a28aee1444b77478025c006fe"
