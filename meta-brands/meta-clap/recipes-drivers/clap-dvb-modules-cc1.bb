KV = "4.4.35"
SRCDATE = "20181010"

require clap-dvb-modules.inc

SRC_URI[md5sum] = "56ea870f48138470faf04ec67aa5c227"
SRC_URI[sha256sum] = "3a24c3ae5183a88dd713bf0058131560319b999ab304ba4543a71f94449b8029"
