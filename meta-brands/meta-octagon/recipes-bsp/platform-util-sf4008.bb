SRCDATE = "20170926"
SRCDATE_PR = "r0"
PV="16.2"

require platform-util.inc

SRC_URI[md5sum] = "247efb6c8d877f46db383fc882980ab5"
SRC_URI[sha256sum] = "7025c8b35edc1409750528133f80a11cc9c9b90835c9296039ad802f1362a372"
