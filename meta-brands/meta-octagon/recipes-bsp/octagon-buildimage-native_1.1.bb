require octagon-buildimage_${PV}.bb
inherit native
