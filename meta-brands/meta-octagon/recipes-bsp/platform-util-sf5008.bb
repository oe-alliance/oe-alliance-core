SRCDATE = "20171113"
SRCDATE_PR = "r0"
PV="16.4"

require platform-util.inc

SRC_URI[md5sum] = "86addc32999920d220800ab670d5e2b8"
SRC_URI[sha256sum] = "23f2df8fdb1730c7f56760ca0554b94b1d197d1ec6dc44705b51f67b19e21fd2"
