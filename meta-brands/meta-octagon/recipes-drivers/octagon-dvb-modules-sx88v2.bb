KV = "4.4.176"
SRCDATE = "20230616"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "4216a9946834f4ac0fad0b4b14e7858c"
SRC_URI[sha256sum] = "734f55aac6efb9ea8c0c9515492e462e6905331076ee3bde211553973c2a7f8f"
