KV = "4.1.35"
GCCREV = "6.2.0"
SRCDATE = "20161207"

require octagon-dvb-modules.inc
SRC_URI[md5sum] = "78a81923c19fbdcff3f7e63abe8908ae"
SRC_URI[sha256sum] = "13e6bd85adefc8cc6e6fe1ec210e307f272d0a4af6e6fa6eb9434ed61e211633"
