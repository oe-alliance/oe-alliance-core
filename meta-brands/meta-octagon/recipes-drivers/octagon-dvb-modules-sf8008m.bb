KV = "4.4.35"
SRCDATE = "20210402"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "349e8b9be9885559cdd7c8e4797c122c"
SRC_URI[sha256sum] = "e7f03e7ad58c93957054c1fefd4c3dacb94f2aa0fdafd6fe36ffd06ee15ff2fa"

