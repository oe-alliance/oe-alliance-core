KV = "4.4.176"
SRCDATE = "20210826"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "841d3929d4d0f89694b42ecd58bc6cd9"
SRC_URI[sha256sum] = "c7253a897e9460d554448540d4aabad98ce10b04eb7969c23f4628590ec011cb"

