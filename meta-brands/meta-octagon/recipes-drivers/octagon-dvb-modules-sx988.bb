KV = "4.4.176"
SRCDATE = "20220113"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "70619eb6c333ddc174e5512c0523ae68"
SRC_URI[sha256sum] = "282dcaa1b375524e6bd2113821fb02fb6e25e1e6509cf86e05fd84b483315c47"

