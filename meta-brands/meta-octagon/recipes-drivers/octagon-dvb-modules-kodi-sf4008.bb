KV = "4.1.37"
GCCREV = "6.3.0"
SRCDATE = "20180114"

require octagon-dvb-modules-kodi.inc

SRC_URI[md5sum] = "ce63d2811455bcc661b1038be936cf75"
SRC_URI[sha256sum] = "3775b909831430408dfc6132837cc0b9d6a485e31b1d2ea7096a548f08973a93"
