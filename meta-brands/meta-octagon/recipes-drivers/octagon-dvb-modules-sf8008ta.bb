KV = "4.4.176"
SRCDATE = "20210806"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "0f14c1de39f9096605d75287ce9dc343"
SRC_URI[sha256sum] = "d2a9bded5d71484ac0405ad4a599dce8c6ad98f0336a6f4a2b156feaf0741d90"

