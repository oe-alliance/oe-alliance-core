KV = "4.4.176"
SRCDATE = "20220921"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "71f702c7a9f2321cfdd1da3413aed291"
SRC_URI[sha256sum] = "c1e0b4802b2341d4bddeb7a314de4be4582ff4a32b32032287171834b5ea4bb5"
