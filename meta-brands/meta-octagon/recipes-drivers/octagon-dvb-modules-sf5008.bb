KV = "4.9.9"
GCCREV = "6.3.0"
SRCDATE = "20170915"

require octagon-dvb-modules.inc
SRC_URI[md5sum] = "4af34afe75e24aa3ee5defee01d079e7"
SRC_URI[sha256sum] = "b919a6b44bdb930f95392d9a9572d98d1e315e1db9f3e2417354f962e149a23c"
