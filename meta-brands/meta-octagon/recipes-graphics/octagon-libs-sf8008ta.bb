SRCDATE = "20210806"

require octagon-libs.inc

SRC_URI[md5sum] = "699bb6e7b5fc64dca45ed6bbce6f4531"
SRC_URI[sha256sum] = "e190e7ebc38763ae2ff279e291bdc79daa4d803b73fe7875bb853bff03d4840f"
