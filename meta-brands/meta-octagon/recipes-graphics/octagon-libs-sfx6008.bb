SRCDATE = "20220326"

require octagon-libs.inc

SRC_URI[md5sum] = "34f18ea09f3f4394a6be80dce670edfa"
SRC_URI[sha256sum] = "9933500c8eaf383dfce41fddeeef436ad6b5d4a50cff17eeaff74d23a5b57f83"
