SRCDATE = "20170920"

require nextv-v3ddriver.inc

SRC_URI[md5sum] = "90a79d50429c98fffa3c691c6e442e22"
SRC_URI[sha256sum] = "b2d245d1ebd7e12cfdeecc3d412452761970759d5c94f6f41f81d428f5d5d9f7"

COMPATIBLE_MACHINE = "sf4008"
