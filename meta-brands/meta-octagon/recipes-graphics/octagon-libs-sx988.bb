SRCDATE = "20211220"

require octagon-libs.inc

SRC_URI[md5sum] = "63b2800c29a1396033a4946c3379614b"
SRC_URI[sha256sum] = "03dbe9afe3e473c494db7b7c420a2f520b77bdc2c2d7d1b0bc3d875cd6a9ec17"
