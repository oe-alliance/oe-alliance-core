SRCDATE = "20221203"

SRC_URI[md5sum] = "5debe901721e8017b0fa86dd417a2834"
SRC_URI[sha256sum] = "1d67229ec9bad6bd398c2e4c41cc12647abf8031e2da7ca21f3d6deb44dde4e3"

require octagon-opengl.inc
