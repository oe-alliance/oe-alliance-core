SRCDATE = "20180831"

require octagon-libs.inc

SRC_URI[md5sum] = "033db54323101b51edf84925f2f243c1"
SRC_URI[sha256sum] = "e90df567adc40214baccd28d28340c3bf3120971b36604a8947c5f7c1280dce4"
