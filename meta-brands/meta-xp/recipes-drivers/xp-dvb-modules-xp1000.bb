KV = "4.10.12"
SRCDATE = "20200402"

require xp-dvb-modules.inc
SRC_URI[md5sum] = "1161f9a05bc7f198ba08156e4eadcb86"
SRC_URI[sha256sum] = "f6b64e96d972060eee8e90e97858a822ee79d1a4f2ba4e5bba5a2898e80f0877"
