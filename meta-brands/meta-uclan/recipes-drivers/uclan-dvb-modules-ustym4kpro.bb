KV = "4.4.35"
SRCDATE = "20181010"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "9da69f3a75a224e4bfdbcca3bb9bf77b"
SRC_URI[sha256sum] = "1e1baa065a91ce02f840d4139e63af914f36857a8376d57e779d071ae68618bb"
