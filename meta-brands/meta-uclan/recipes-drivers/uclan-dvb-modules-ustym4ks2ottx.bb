KV = "4.4.176"
SRCDATE = "20230804"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "9bc74a90af3546208ef1d17cd02eb338"
SRC_URI[sha256sum] = "604b6e5c7b7b5c456c467c5a82fe18f5cab3664677b729d9763404f9d7d10d50"
