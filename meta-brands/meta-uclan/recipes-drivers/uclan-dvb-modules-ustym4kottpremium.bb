KV = "4.4.176"
SRCDATE = "20220113"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "bddcc9d9df93e089544a3fad583b833e"
SRC_URI[sha256sum] = "950ce383899b50a63b3348d3c743aa604032ebc73d72f70298bf397a47faa8e4"

