KV = "4.4.176"
SRCDATE = "20211230"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "0f9ac116390a80cdbca211d04d083621"
SRC_URI[sha256sum] = "13390b20a43697af06c72b8110e3949c4f87464768aab43faaa791dc259045f7"

