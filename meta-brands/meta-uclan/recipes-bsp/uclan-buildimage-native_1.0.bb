require uclan-buildimage_${PV}.bb
inherit native
