SRCDATE = "20190306"

require uclan-libs.inc

SRC_URI[md5sum] = "981f164601f6d025410f44b29c115558"
SRC_URI[sha256sum] = "57728030977989b18ff234f8af52712246628fc2e259fb03c7e97c08d12d78bd"
