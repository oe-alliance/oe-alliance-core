SRCDATE = "20211220"

require uclan-libs.inc

SRC_URI[md5sum] = "8a0664db15f42b9152c67470644af626"
SRC_URI[sha256sum] = "5dcc6f62dfe2acec7c0143ecefa8775ea77ce1618ec3292291db8c41a6eb36a2"
