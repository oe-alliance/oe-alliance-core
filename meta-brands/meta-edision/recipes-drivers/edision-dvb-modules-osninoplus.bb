KV = "4.8.17"
SRCDATE = "20191008"
KOFILES = "linuxdvb"

require edision-dvb-modules.inc
SRC_URI[md5sum] = "97560a5876f3415f60c84ed0ffb77cd6"
SRC_URI[sha256sum] = "3e818bcd97135f4e43f32eba3b203e01baa3ca5856aa957987f45c7c03a93d3d"
