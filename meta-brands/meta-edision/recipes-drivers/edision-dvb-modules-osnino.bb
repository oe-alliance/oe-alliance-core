KV = "4.8.17"
SRCDATE = "20191008"
KOFILES = "linuxdvb"

require edision-dvb-modules.inc
SRC_URI[md5sum] = "861b8f78cd8727512e4e56e6d00ef741"
SRC_URI[sha256sum] = "cc0905740c2be6fb6e04166e9ff689b1fc92becfb0c1dd6117e0f01702627c5b"
