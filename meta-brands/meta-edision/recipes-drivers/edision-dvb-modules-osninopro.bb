KV = "4.8.17"
SRCDATE = "20181015"
KOFILES = "linuxdvb"

require edision-dvb-modules.inc
SRC_URI[md5sum] = "8afbec990943ad31a6a383defc2f8a71"
SRC_URI[sha256sum] = "bd0902a6d94a369bcff3dc5dfb97457cc47c2f6cf46d5502cb43109de5b36c5a"
