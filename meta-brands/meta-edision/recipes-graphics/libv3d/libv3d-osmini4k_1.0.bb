require libv3d.inc

PR = "r0"

SRC_URI[md5sum] = "032b9a9e3040f841d88b007c8f217c06"
SRC_URI[sha256sum] = "dea5169e61a4b200e676af3601aa9599f84cf24ff49b064db889d9b5a77a1724"
