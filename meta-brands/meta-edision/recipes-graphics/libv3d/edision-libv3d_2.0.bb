require libv3d.inc

PR = "r2"

SRC_URI[md5sum] = "9daf29bbe41a483cec87a3ca4c55ef13"
SRC_URI[sha256sum] = "e46a322e19859c013f76f3e6f827d44fb9b74d01d6294348b3c41915ffa8e23d"
