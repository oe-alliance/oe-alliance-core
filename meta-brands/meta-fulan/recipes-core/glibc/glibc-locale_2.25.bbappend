BINARY_LOCALE_ARCHES += "sh4"
