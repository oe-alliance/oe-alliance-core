CFLAGS:remove:sh4 = "-Wno-stringop-overflow"
CFLAGS:append:sh4 = " -std=gnu11"
