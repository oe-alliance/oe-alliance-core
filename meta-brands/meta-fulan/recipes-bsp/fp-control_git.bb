DESCRIPTION = "A tool for uploading the firmware to the slave DSPs"

require ddt-apps.inc


