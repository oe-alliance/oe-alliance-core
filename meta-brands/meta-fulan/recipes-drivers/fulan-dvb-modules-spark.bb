require fulan-dvb-modules.inc

PR = "${INC_PR}"
