CFLAGS:append:sh4 = " -std=gnu99"


