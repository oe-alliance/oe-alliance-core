SRCDATE = "20200818"

require airdigital-bootlogo.inc

SRC_URI[md5sum] = "db93cc0667a83dedfc0cab59985929ba"
SRC_URI[sha256sum] = "404936c4bdb137c02388c9460f19bd888612d7985f8c110851b51da66fec1c82"

COMPATIBLE_MACHINE = "hzero|^h8$"

