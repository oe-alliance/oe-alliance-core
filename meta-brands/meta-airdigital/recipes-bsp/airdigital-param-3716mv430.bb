SRCDATE = "20200508"

require airdigital-param.inc

SRC_URI[md5sum] = ""
SRC_URI[sha256sum] = ""

COMPATIBLE_MACHINE = "hzero|^h8$"

