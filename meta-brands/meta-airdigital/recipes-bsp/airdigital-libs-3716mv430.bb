SRCDATE = "20200818"

require airdigital-libs.inc

SRC_URI[md5sum] = "64775b4a39f2779b23e1919bfdf634c4"
SRC_URI[sha256sum] = "21eef199f0547173ef3cbcb0a08f4dab5c430a17ef94516bf8e87e6273b877ba"

COMPATIBLE_MACHINE = "hzero|^h8$"
