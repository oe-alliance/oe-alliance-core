SRCDATE = "20210324"

require airdigital-libs.inc

SRC_URI[md5sum] = "32a832b936b81a0ab7327a04afca4350"
SRC_URI[sha256sum] = "4540dace298b5b115507d310a6fba72e5abb3b49f487ca73270cf2fbc3367fdf"

COMPATIBLE_MACHINE = "^h11$"
