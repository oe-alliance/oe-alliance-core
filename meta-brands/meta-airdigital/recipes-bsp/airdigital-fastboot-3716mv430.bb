SRCDATE = "20210915"

require airdigital-fastboot.inc

SRC_URI[md5sum] = "e67941ef7d0f741986b6acff4550b7ea"
SRC_URI[sha256sum] = "761d61034d0e2127672895e52826da8ea736bb32620ce417ee33d39625585c1d"

COMPATIBLE_MACHINE = "hzero|^h8$"
