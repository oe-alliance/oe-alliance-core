SRCDATE = "20260402"

require airdigital-bootlogo.inc

SRC_URI[md5sum] = "750f895ae50c13f4047228603b6e2cf5"
SRC_URI[sha256sum] = "ddd6acda2546e341a6fb6b2cd2d39cc242a878aece6a2615f8d4682ba2e1f723"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"
