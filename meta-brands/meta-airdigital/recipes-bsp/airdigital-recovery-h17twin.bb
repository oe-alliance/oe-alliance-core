SRCDATE = "20251016"

HICHIPSET = "${MACHINE_DRIVER}"

require airdigital-recovery.inc

SRC_URI[md5sum] = "694c98cd32e8c8fbf21ea8742d60f73b"
SRC_URI[sha256sum] = "863ebf024c4a2883ef58c91b0fbf42a6d84f33af6f5b8f9e2ffe21928919e4ad"

COMPATIBLE_MACHINE = "^h17$"
