SRCDATE = "20180830"

require airdigital-bootargs.inc

SRC_URI[md5sum] = "ec0b8d286e076aab6aea9b6985cb1201"
SRC_URI[sha256sum] = "4d509f6138d2106ba512c1c0bd51a0a4b0b615fde21bde0f74e9433dbbae8e4e"
