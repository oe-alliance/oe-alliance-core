SRCDATE = "20210120"

require airdigital-fastboot.inc

SRC_URI[md5sum] = "4138345d82f4e3c76109248900fe51c2"
SRC_URI[sha256sum] = "f77a31d3fc2c819be90e0b62a270d0e842a2997f52f97a0a0c69d04f426852f4"

COMPATIBLE_MACHINE = "^h11$"
