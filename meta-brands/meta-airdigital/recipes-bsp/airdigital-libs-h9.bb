SRCDATE = "20180828"

require airdigital-libs.inc

SRC_URI[md5sum] = "0a15b8518eb15585cebbd2aa2f716cc5"
SRC_URI[sha256sum] = "9c0daeb3a6f5c73b7492b2429207144ad5362510993a57afb0b682a6d5f0d299"

COMPATIBLE_MACHINE = "h9"