SRCDATE = "20181107"

require airdigital-param.inc

SRC_URI[md5sum] = "e96562a5f0cbe388d55aa52a1f744339"
SRC_URI[sha256sum] = "7e45e8898e30cda6bf37b46a8d6b43beed79dcfffa973d637126d068b1e4391d"

COMPATIBLE_MACHINE = "h10|h9|i55plus|h9combo"