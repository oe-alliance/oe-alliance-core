SRCDATE = "20260915"

require airdigital-bootargs.inc

SRC_URI[md5sum] = "bcc03fdcb7ce150e23e7839e26c72ce8"
SRC_URI[sha256sum] = "238f7ede1ef7b5b4e84f180e95157d7f189e6eedf80664c2e01ef6b938c4a746"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"
