SRCDATE = "20260403"

require airdigital-fastboot.inc

SRC_URI[md5sum] = "eb36d3ed10958d8db705b8acfd3caf20"
SRC_URI[sha256sum] = "04105b0fdf966d5a130afae692e85dd309a846c89c09128d719aeb01f9a3c17d"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"
