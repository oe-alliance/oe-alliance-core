SRCDATE = "20210120"

require airdigital-bootargs.inc

SRC_URI[md5sum] = "7b0e7618b27ebbfaed32a0184614c9b3"
SRC_URI[sha256sum] = "c7db0e022ab991ff783b481abe579ee7928aa4d36c23b45293948e54a30e2fb7"

COMPATIBLE_MACHINE = "^h11$"
