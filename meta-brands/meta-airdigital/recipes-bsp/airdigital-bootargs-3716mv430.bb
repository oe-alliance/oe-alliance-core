SRCDATE = "20210915"

require airdigital-bootargs.inc

SRC_URI[md5sum] = "301fddbef9bf6dcf40b8e6b83ced8ba4"
SRC_URI[sha256sum] = "72c7bc5f46bbeebb776c93213ab40cd002b5dde82c3d3612d97b23abea1cf1da"

COMPATIBLE_MACHINE = "hzero|^h8$"
