SRCDATE = "20180830"

require airdigital-bootargs.inc

SRC_URI[md5sum] = "94ed2b1e39b49cb5d0ac7f3a79ec6ed3"
SRC_URI[sha256sum] = "698b83f9cc683782ff2c5f648f3e0329714ef2e85f08a9ce70318e53c344ba54"
