SRCDATE = "20210914"

require airdigital-recovery.inc

SRC_URI[md5sum] = "3d51a1028df38f968c14667e9b1776f4"
SRC_URI[sha256sum] = "be4037b1b5083ce51f893b140f84978e94a9e3c9d7faec18cb7d6aefdc057144"

COMPATIBLE_MACHINE = "^hzero$|^h8$"
