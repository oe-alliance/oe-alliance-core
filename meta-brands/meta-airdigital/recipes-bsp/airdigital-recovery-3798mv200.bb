SRCDATE = "20260402"

require airdigital-recovery.inc

SRC_URI[md5sum] = "7f02a7f8c4bdd20d56e428bbc2084c9a"
SRC_URI[sha256sum] = "cd56fb6d47c8ac9e3fafbf643fd8f17457dc83722e0977cb557d800d7af15ae3"

COMPATIBLE_MACHINE = "^h8se$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55se$"
