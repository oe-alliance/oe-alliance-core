SRCDATE = "20170320"

require airdigital-v3ddriver.inc

SRC_URI[md5sum] = "34b7d8902f9ef0f51a8d0ad4ca19cb9c"
SRC_URI[sha256sum] = "b961c24fe16592a171d12282c29ca38cc299da5cc1a25da8d987e2f8954f4dbe"

COMPATIBLE_MACHINE = "h7"