SRCDATE = "20180228"

require airdigital-libs.inc

SRC_URI[md5sum] = "e301110871d87abaac35d4eb812eece6"
SRC_URI[sha256sum] = "5ee6b4522f55ceac39ac11b05c1a689273019b9a3291da58077cd3a53816ad75"

COMPATIBLE_MACHINE = "h9"