SRCDATE = "20191110"

require airdigital-v3ddriver.inc

SRC_URI[md5sum] = "9ab30bdb3103c1db0b9cf0989d383de8"
SRC_URI[sha256sum] = "6278326c03f21c50e660dbb91f49154c67df3ea8bee55fe8fe6844338ab994ac"

COMPATIBLE_MACHINE = "h17"
