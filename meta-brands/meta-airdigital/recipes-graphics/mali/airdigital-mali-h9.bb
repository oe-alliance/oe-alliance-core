SRCDATE = "20171106"

require airdigital-mali-utgard.inc

SRC_URI[md5sum] = "472e99bac874f952f82453d56f1a76a6"
SRC_URI[sha256sum] = "a163527eac4ff1782601d3927bff1f2c726b3d891d056c004753d0f09fe3c23f"

COMPATIBLE_MACHINE = "h9"