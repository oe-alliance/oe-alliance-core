SRCDATE = "20211026"

require airdigital-mali-utgard.inc

SRC_URI[md5sum] = "d2f5ba6437c41e614400dc1fe11ff0ee"
SRC_URI[sha256sum] = "a177c4f19d3178526da8c5614973b307dd8ed970cc8be554e07a7120ba912b11"

COMPATIBLE_MACHINE = "^h11$"
