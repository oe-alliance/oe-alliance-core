SRCDATE = "20180323"

require airdigital-libs.inc

SRC_URI[md5sum] = "bc5b1248598add6e64b2cc4b66a88b0a"
SRC_URI[sha256sum] = "c942aa050e256416db813e0288f31594a1e16d347bd50582df6c54c78d3f7ec7"

COMPATIBLE_MACHINE = "h9"
