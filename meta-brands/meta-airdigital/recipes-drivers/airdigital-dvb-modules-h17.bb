KV = "4.10.12"
SRCDATE = "20250429"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "bf50c1df010901060fb4b25256207e2d"
SRC_URI[sha256sum] = "3fdf41544b628b183404fd25903068f7ed1bff05200fac5311a0e2ceb089aaa4"
