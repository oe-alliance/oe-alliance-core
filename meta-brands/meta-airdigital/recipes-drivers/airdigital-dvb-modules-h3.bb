KV = "4.0.1"
SRCDATE = "20151029"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "0ba17f537fcfe5dff9396a8a6ac48684"
SRC_URI[sha256sum] = "74f57fe1491490752091b69da6b74a742d1d268967108637456cefdacaa7d429"

