KV = "4.0.1"
SRCDATE = "20160121"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "07bcfb0b78a1d9ab0d98dab9428c5372"
SRC_URI[sha256sum] = "bb4f38725e87803ea3a871be17d93e99ad4efab462fec97ef6dbbf31f54dab3b"

