KV = "4.0.1"
SRCDATE = "20161230"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "71bb95c0477f4d813be06a5d2a8ae69d"
SRC_URI[sha256sum] = "e398c16cc5e18b17e66afa221c3017c4adc190a845371def9e23833f23cde0ae"

