KV = "4.10.12"
SRCDATE = "20250706"

PROVIDES = "virtual/blindscan-dvbs"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "f28c75fdae01453e657b78e1bd7d5a30"
SRC_URI[sha256sum] = "08b6a7db0a63f6776ea2b63840bdf0c5683002a37ca941212c9eb1733a1c9b8f"
