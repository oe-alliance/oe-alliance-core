KV = "4.0.1"
SRCDATE = "20161230"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "a757fa1d77724aee181b4097438049ba"
SRC_URI[sha256sum] = "16f768c063bdd8620578bdb5a52379e7653bfc02e7cd3f4ec07b017df6c97e31"

