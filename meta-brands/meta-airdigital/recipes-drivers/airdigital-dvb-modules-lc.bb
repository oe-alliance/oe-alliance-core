KV = "4.0.1"
SRCDATE = "20161230"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "47a2e182822350be80b08be636858ad6"
SRC_URI[sha256sum] = "32cfd3d0f321ad75586a4cbbf4c0a4fffecff365f39f644b68fb7834974760c4"

