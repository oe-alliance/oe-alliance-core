KV = "4.0.1"
SRCDATE = "20161230"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "4ba23fdbf9100149cac020ff00b167dc"
SRC_URI[sha256sum] = "2afba71dd5e3e2b20f8984350b243127bea519e76cb9a76bc8f572de7a5743ba"

