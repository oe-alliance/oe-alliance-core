KV = "4.0.1"
SRCDATE = "20161201"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "40b1cb576d5ee44023399ce7f8ab65b2"
SRC_URI[sha256sum] = "3fcb00783b7545a232abe8ccdbaef07a6a6c960a460c9dfc9a4512e225067187"

