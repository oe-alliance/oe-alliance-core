KV = "4.0.1"
SRCDATE = "20160621"

require airdigital-dvb-modules.inc

SRC_URI[md5sum] = "f2a90adc4e814030667c1fe9d2e58690"
SRC_URI[sha256sum] = "fe1b3a11534f9ddff78072423a5111b585b2d3d597bef87582c4461ff8179994"

