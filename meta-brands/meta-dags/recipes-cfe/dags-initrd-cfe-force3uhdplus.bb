SRCDATE = "20161223"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "c02c323359bcde3529175e220441e91b"
SRC_URI[sha256sum] = "86fd9c3528a4505a54654dfb0b58b42e6749f3cddd0532bce50d4464ca63bde6"
