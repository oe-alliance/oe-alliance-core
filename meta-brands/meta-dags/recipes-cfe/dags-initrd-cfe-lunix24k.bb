SRCDATE = "20180705"
CHIPNAME = "7260a0"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "4e86abf788c9f21bc61620aae02ef975"
SRC_URI[sha256sum] = "a4aca2c534b16a430681cbe0ea657c5680e2272dabe59508fc399c975795feab"
