SRCDATE = "20161223"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "a3ccd804c0aa4ef2ec7e21278f1b80c2"
SRC_URI[sha256sum] = "b332e0d702e3314b27c7619c53a54f88b50d335d52d814e58ac689613cfd9708"
