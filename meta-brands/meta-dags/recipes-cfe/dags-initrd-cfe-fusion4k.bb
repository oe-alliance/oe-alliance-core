SRCDATE = "20170106"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "3b07468cf880a09081d6256867492103"
SRC_URI[sha256sum] = "89b486736457c14f75984cfe3c8bb236d4a1a51771085992fea7344876daf163"
