SRCDATE = "20190307"
CHIPNAME = "7260a0"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "45dd1cff79258432cab6bbf0226ce353"
SRC_URI[sha256sum] = "00c7c13e3f75c0d34666c922e65e255a8d54461d62409d69b09653acc11a97bd"
