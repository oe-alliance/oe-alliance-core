SRCDATE = "20161223"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "b6a51d92759880c892d700b67c3e3685"
SRC_URI[sha256sum] = "58c4b50a471909640f2320c6339f8dd0b2b5997f7a37568cc0ebee215cf09624"
