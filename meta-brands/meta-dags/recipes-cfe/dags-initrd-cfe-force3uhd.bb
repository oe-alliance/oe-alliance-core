SRCDATE = "20161223"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "27b57cd7afb8451c26d8331123a4ce96"
SRC_URI[sha256sum] = "5aa3d9d390a3b78ac803dd2e6354cd3f5604114b252dc06a2557fe525715cfb6"
