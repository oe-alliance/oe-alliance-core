SRCDATE = "20170801"
DOWNLOADNAME = "lunix3-4k"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "90c5d6df77953d15c5a015715862d358"
SRC_URI[sha256sum] = "a613de89759fd32a957c2492b35f55cd49af8a42133acbb11cf5ca9f8f7f883f"
