SRCDATE = "20170106"

require dags-initrd-cfe.inc

SRC_URI[md5sum] = "4142ae07cadcd25996dd7cb29be99ed5"
SRC_URI[sha256sum] = "404e927c7344b3381ef3a6f8aeaf149c9c5921e45d8a45bc1037ea4810af9059"
