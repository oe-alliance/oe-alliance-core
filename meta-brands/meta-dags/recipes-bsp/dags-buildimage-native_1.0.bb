require dags-buildimage_${PV}.bb
inherit native
