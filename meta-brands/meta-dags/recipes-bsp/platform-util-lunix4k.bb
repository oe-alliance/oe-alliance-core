require platform-util.inc
