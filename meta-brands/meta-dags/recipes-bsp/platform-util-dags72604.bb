require platform-util.inc

COMPATIBLE_MACHINE = "^(force4|lunix4k)$"

PV="17.1"

S="${WORKDIR}/platform-util-${MACHINE}"

SRC_URI[md5sum] = "d0bd0250b563b65178809f0ab196b01f"
SRC_URI[sha256sum] = "6b72a7d9930ebb45886b51ca81fca1374acdef27e1c842934ccebf86bac7878c"
