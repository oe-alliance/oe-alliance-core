KV = "4.4.35"
SRCDATE = "20210715"

require dags-dvb-modules-hisi.inc

SRC_URI[md5sum] = "f57923476d78a7fbe1ee66d17861ff87"
SRC_URI[sha256sum] = "774a3944fd5e86524e764e37bddea2c01243b3e9bc4309d6d67c0cf0b0d93a0c"
