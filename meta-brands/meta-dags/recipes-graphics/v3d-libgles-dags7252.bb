require v3d-libgles-dags.inc

SRCDATE = "20190123"
SRCDATE_PR = "r0"
PV="16.1"

SRC_URI[md5sum] = "60f42226b53bad353f227c2106e7f63a"
SRC_URI[sha256sum] = "9c3ea23dabf7b7c4b110b9c6b89f0791b5079fe830262d176f7b5c053aa10c86"
