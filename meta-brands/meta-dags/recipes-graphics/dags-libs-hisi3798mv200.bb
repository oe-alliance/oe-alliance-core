SRCDATE = "20211230"

require dags-libs.inc

SRC_URI[md5sum] = "99e4e7f6cad1c96480d5050b326d8eba"
SRC_URI[sha256sum] = "172225fde31ad6dd768327a259c6c0bf9fbb52f4a1edc1928f92ce631007579c"
