SRCDATE = "20200915"

SRC_URI[md5sum] = "796497b786062ff2641285eaf4717d0b"
SRC_URI[sha256sum] = "95f4ecd9c90f07075dd24493baa4a440d6140007d33e9238fc37de111ae2c574"

require dags-opengl.inc
