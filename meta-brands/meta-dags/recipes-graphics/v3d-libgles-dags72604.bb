require v3d-libgles-dags.inc

SRCDATE = "20190218"
SRCDATE_PR = "r0"
PV="16.1"

SRC_URI[md5sum] = "a55fc2f8877e4e46ebdf12e74ca2195b"
SRC_URI[sha256sum] = "a21a8534ff81d4fd75accddf1f7b44aefe68a70e478fa71faba37ca4d703070d"
