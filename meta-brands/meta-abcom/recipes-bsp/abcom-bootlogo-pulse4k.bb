SRCDATE = "20210312"

require abcom-bootlogo.inc

SRC_URI[md5sum] = "59d70d2e0715b19817c63146ea66309a"
SRC_URI[sha256sum] = "5c18737d0a6ea81f83a0631c0caa116590773a28e401fcb0cedc8ecb4f899fef"
