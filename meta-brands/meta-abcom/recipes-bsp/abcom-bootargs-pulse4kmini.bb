SRCDATE = "20210624"

require abcom-bootargs.inc

SRC_URI[md5sum] = "538022f879d23f7efa5c9dfcfb867c85"
SRC_URI[sha256sum] = "7a8fc3182c8aa012fe1997b6b7f0378cf3a96242568973de36106c17bb25f529"
