SRCDATE = "20210624"

require abcom-param.inc

SRC_URI[md5sum] = "2db9334d8529c2d5d5d2e4d417fc9d5d"
SRC_URI[sha256sum] = "037ac3d703a7100d015a65c87c9ef031361df450c4ac3db5779970db54a3e921"
