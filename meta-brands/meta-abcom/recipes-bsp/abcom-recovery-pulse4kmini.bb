SRCDATE = "20210624"

require abcom-recovery.inc

SRC_URI[md5sum] = "0f010f063b4dd328690c52d1f2b4e9f9"
SRC_URI[sha256sum] = "9e8b66443c7018c0203ee21319925cc1bceee531c6686a5ac212705aeb4ed5f1"
