SRCDATE = "20210624"

require abcom-bootlogo.inc

SRC_URI[md5sum] = "dc390edc500661a634aa0331dbbd042a"
SRC_URI[sha256sum] = "08a96815ec1cb4ea6a0ff67ba60a39a833166525caa248ef702079cd2f29f917"
