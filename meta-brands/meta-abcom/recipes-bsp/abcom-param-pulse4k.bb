SRCDATE = "20210329"

require abcom-param.inc

SRC_URI[md5sum] = "63e193596062a81c6de8e0437b412dbb"
SRC_URI[sha256sum] = "313c10c4a85c9b7ad8059f73373adfa343542a968ae943dfa35ad5ed8139c494"
