SRCDATE = "20210312"

require abcom-bootargs.inc

SRC_URI[md5sum] = "0a7fd5c737b47f76aaa24421a9e790da"
SRC_URI[sha256sum] = "ba1aacc53ab47038b07c031de6a9762cb13cf3f061c8b25b727aaff2731c8eac"
