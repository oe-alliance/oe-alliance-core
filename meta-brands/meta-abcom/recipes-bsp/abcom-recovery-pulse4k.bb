SRCDATE = "20210312"

require abcom-recovery.inc

SRC_URI[md5sum] = "7ceac4ac9ee8d3f8e2a792ddcda1d4be"
SRC_URI[sha256sum] = "444a8ace135fbd641e46b15cf26bf71457211f47eedd368dc0cc810628ce6464"
