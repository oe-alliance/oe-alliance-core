SRCDATE = "20220307"

require abcom-libs.inc

SRC_URI[md5sum] = "560c8dacc7e842e0fc8cf8abeae85bb2"
SRC_URI[sha256sum] = "5b0b6c6fb0ea1de1304fcdbd992f597028b62a64239a02e5a83fd9944ea7d7d3"
