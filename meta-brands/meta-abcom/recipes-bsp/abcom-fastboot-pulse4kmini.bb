SRCDATE = "20210624"

require abcom-fastboot.inc

SRC_URI[md5sum] = "7c8f5fa9bc325c61e855a82418b70a8b"
SRC_URI[sha256sum] = "1fe7ec2ddda9d909a98fe67040edfe6ccd842dd91ae1b62f3c3e913fcd218d80"
