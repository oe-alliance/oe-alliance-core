SRCDATE = "20170322"

require formuler-v3ddriver.inc

SRC_URI[md5sum] = "1bdd9487a74a408f09f21ce35fe3800b"
SRC_URI[sha256sum] = "7111ff8efcb3f33dcf4da1036ed9a5b8c18f5db988c03d26d74ac425e454cbbb"

COMPATIBLE_MACHINE = "formuler1"