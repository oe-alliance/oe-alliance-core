KV = "4.10.6"
SRCDATE = "20170419"

require formuler-dvb-modules-al.inc
SRC_URI[md5sum] = "ffc64da6f3e12fd6cafdc3e125bc3e8c"
SRC_URI[sha256sum] = "368d43c5395a829fad7a999a36aea63d5324b0fbce6077cb2445cbe687ef17df"
