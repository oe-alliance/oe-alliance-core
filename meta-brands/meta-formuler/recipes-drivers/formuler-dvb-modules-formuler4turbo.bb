KV = "4.7.4"
SRCDATE = "20160928"

require formuler-dvb-modules.inc
SRC_URI[md5sum] = "f1ecf4d8c9a6032f8beaa83553562547"
SRC_URI[sha256sum] = "f2c4c615062a01dd60b8a3663e2fe0420d8d731872ac9a212982739c94eb4418"
