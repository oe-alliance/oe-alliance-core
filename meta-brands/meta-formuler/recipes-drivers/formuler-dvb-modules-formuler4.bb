KV = "4.7.6"
SRCDATE = "20161212"

require formuler-dvb-modules.inc
SRC_URI[md5sum] = "b395e545b7b0a94d96438ed23ca94dc4"
SRC_URI[sha256sum] = "4369c7dbf6828b716ad5d876579dee378e788eddc193323b14205c12fa548a41"
