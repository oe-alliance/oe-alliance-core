KV = "4.10.6"
SRCDATE = "20170419"

require formuler-dvb-modules-al.inc
SRC_URI[md5sum] = "43989826c0d376db159ce42c3f9dcdbb"
SRC_URI[sha256sum] = "e41116da6709346a3314db90124bec14343c5bd8ffa56e4d16f507a16577b08b"
