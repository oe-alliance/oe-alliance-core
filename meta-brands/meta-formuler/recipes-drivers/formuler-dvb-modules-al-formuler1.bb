KV = "4.10.6"
SRCDATE = "20170419"

require formuler-dvb-modules-al.inc
SRC_URI[md5sum] = "28638c155801c646aec26b9e539c7588"
SRC_URI[sha256sum] = "c062016c7c0967b5525a3640965a6dc4b0b21b0aea2ea9af1573a501ab4ac01b"
