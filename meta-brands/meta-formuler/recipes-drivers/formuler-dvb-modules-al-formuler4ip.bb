KV = "4.10.6"
SRCDATE = "20170419"

require formuler-dvb-modules-al.inc
SRC_URI[md5sum] = "c29e74780f9bd1e2ca957e9cdd613437"
SRC_URI[sha256sum] = "0f8e5505c044a44932eea1574d6f0f0d197be6e1ab81632f4023beb52caa7939"
