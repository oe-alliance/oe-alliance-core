KV = "4.10.6"
SRCDATE = "20170419"

require formuler-dvb-modules-al.inc
SRC_URI[md5sum] = "1ccb0b941035bbfd1e44bbf046d8df69"
SRC_URI[sha256sum] = "d67988d57a926e3431733dd12bebe65d0aa5e1244ff28b953b89df07d899af50"
