KV = "4.10.6"
SRCDATE = "20190530"

require formuler-dvb-modules-al.inc
SRC_URI[md5sum] = "78b69daeca74e9ff360249c600618ae7"
SRC_URI[sha256sum] = "de28fbc92d6d56a4d24eb963f5857b5c5518f40cf85f778fd79d554c691dc099"
