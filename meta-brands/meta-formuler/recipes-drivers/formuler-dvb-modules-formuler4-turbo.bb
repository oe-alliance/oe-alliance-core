KV = "4.0.1"
SRCDATE = "20160907"

require formuler-dvb-modules.inc
SRC_URI[md5sum] = "303e8c3f716a3f68a7c940ef81473504"
SRC_URI[sha256sum] = "41c99fbc6ff268e58f3711d5969e00d373c78e7fee091c536097354965e5b665"
