KV = "4.0.1"
SRCDATE = "20160504"

require formuler-dvb-modules.inc
SRC_URI[md5sum] = "5925a9b08906e3434651284e89905fca"
SRC_URI[sha256sum] = "69a651046ac1855c3748a5709944c8edce083fe6a6dc6adc3bdb36ab2d0881b1"
