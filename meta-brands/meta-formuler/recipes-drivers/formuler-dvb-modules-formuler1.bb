KV = "4.7.6"
SRCDATE = "20170103"

require formuler-dvb-modules.inc
SRC_URI[md5sum] = "7611ba696ae41121544e2a6e7062145b"
SRC_URI[sha256sum] = "28e2c7c3ec2eaf1a6ab6d1dc8ac9f9e809a30746a636d62620c9226ac84ce755"
