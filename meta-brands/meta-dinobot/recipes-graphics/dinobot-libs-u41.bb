SRCDATE = "20190123"

require dinobot-libs2.inc

SRC_URI[md5sum] = "c39d8dbee8e33cc0b28f84cb9c5b8fc9"
SRC_URI[sha256sum] = "c2a24beb8f2b0ef0ac9e5313acdb6e2f41378289420278ff7875ce2998ef9d72"
