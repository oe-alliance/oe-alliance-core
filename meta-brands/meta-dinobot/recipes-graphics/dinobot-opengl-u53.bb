SRCDATE = "20180428"

SRC_URI[md5sum] = "23a70ad3b28a34f9cbfac4ed1c4c2023"
SRC_URI[sha256sum] = "e2e599de7b521c51e3d9b3b4c6b3bcf99e2cdd2d7ac5b5be8fb686b3d9c23fea"

require dinobot-opengl.inc
