SRCDATE = "20180830"

SRC_URI[md5sum] = "829e621064e1f62016e06e76c97724b6"
SRC_URI[sha256sum] = "082ef4a187d39464c8d078a033e11518dfd987c2d96ecbf615f9c4aa54b28190"

require dinobot-opengl.inc
