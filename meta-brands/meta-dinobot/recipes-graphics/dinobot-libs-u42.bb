SRCDATE = "20190715"

require dinobot-libs2.inc

SRC_URI[md5sum] = "9898d1d323709b63d399a7039949b894"
SRC_URI[sha256sum] = "cc5b51761752c922f16531437aded3ae195b8d0f74105e106e0f3f6533477a69"
