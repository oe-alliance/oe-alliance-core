SRCDATE = "20180428"

SRC_URI[md5sum] = "279b86ff4b804aa2b97ab2d6ca7026a9"
SRC_URI[sha256sum] = "0504bdcb94cc7de89901cabef50c58b55623c715d022596c6683c2aa751d978b"

require dinobot-opengl.inc
