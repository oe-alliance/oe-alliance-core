SRCDATE = "20190729"

require dinobot-libs2.inc

SRC_URI[md5sum] = "cb33c37ec0ef467b92fc6571096bc1ff"
SRC_URI[sha256sum] = "1f424e41097b8d2f1dbe92f68b9b960f27fd360b3ecd39b21897beb201922f01"
