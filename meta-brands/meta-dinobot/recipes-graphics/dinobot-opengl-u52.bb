SRCDATE = "20180428"

SRC_URI[md5sum] = "19fce77a2885f2aa164270b7255d53bb"
SRC_URI[sha256sum] = "0fd363bf66f4c3a9823c53f70692f9f6d73f37a7f29f9c939b3c8704f1798b3b"

require dinobot-opengl.inc
