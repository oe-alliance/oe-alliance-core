SRCDATE = "20180428"

SRC_URI[md5sum] = "e180dc5e55a8dadc0a1a0c921f2db293"
SRC_URI[sha256sum] = "74eb66225635fd6623d7576e30099967add0c53a2a42a316f63370d45c93f170"

require dinobot-opengl.inc
