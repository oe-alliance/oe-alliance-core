SRCDATE = "20210604"

require dinobot-libs2.inc

SRC_URI[md5sum] = "9df65c8e981cdd82704f26067da73d6a"
SRC_URI[sha256sum] = "bdf5b1ae03f3d73c850603237861171bb39d5b0d09ee94fa5f294a1508b4e009"
