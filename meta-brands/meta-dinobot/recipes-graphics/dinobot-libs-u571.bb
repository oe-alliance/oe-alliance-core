SRCDATE = "20210727"

require dinobot-libs2.inc

SRC_URI[md5sum] = "a00bd0c5099daa7914eee39716ebe4d1"
SRC_URI[sha256sum] = "f6055d58eb31f3e907bed14e0ffa09874a69d12dbb863e24cf17447f36bbe9c6"
