SRCDATE = "20180428"

SRC_URI[md5sum] = "7df8ce1d54beede884f0f62559264bdf"
SRC_URI[sha256sum] = "cc49fe0c17de6bf7615a9841b47e41b418cba363afbaf8282e0692ef33073f98"

require dinobot-opengl.inc
