SRCDATE = "20180427"

require dinobot-libs.inc

SRC_URI[md5sum] = "b85f510dba3d46c075fec9a03a9f0753"
SRC_URI[sha256sum] = "6b7042bf6a2f0a5affd24bdc80f0e2b0a987105271e210f181a76d425467d369"


