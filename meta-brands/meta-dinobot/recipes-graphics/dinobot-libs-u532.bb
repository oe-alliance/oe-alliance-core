SRCDATE = "20190708"

require dinobot-libs2.inc

SRC_URI[md5sum] = "835d5efdec30c627f0e442086e3cd871"
SRC_URI[sha256sum] = "2221b3f2dd5ef8563155aebc1d442ceeff641b1692faff7e09459a68f2a5a69e"
