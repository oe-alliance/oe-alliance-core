SRCDATE = "20210325"

require dinobot-libs2.inc

SRC_URI[md5sum] = "4e1a3d952200080c18dd271f0a48493d"
SRC_URI[sha256sum] = "541fc89d89dc142b8ccb688afa967e41bd692a16d278949c0c54ac42f590127e"
