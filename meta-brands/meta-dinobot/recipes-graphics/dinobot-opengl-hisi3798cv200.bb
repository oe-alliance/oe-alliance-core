SRCDATE = "20210918"

SRC_URI[md5sum] = "ad503bb0fd304d2d93e8550484c44464"
SRC_URI[sha256sum] = "8fa8c246f05a0038cc397d306eb4c3e7c1ce9d38620b738bbe0b62c12e42b225"

COMPATIBLE_MACHINE = "^(u5pvr|u53|u532|u533)$"

require dinobot-opengl.inc
