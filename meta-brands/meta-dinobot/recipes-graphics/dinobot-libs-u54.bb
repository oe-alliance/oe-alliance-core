SRCDATE = "20191025"

require dinobot-libs2.inc

SRC_URI[md5sum] = "35c73fb2f1e43525a31f6c6396ac5779"
SRC_URI[sha256sum] = "4f2c971006a80529e831b0b2543e9caeda9da40a5aa232dabcf40468dc808c3a"
