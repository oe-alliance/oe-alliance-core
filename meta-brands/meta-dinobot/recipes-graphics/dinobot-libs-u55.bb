SRCDATE = "20191011"

require dinobot-libs2.inc

SRC_URI[md5sum] = "d95ca77d0645dd9535a169f7e271b8a3"
SRC_URI[sha256sum] = "fdda51307849b878889aa4ec03daf7026ac5a322bc49b008c5d543b9337f4159"
