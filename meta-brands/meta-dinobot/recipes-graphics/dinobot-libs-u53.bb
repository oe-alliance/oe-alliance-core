SRCDATE = "20190929"

require dinobot-libs2.inc

SRC_URI[md5sum] = "9eff125083e3b2abadb0816937f6c779"
SRC_URI[sha256sum] = "b670ae4d5bd5d1b8ffbf1d2b830555492966b4b514ee0099b51b092d91f16dd4"
