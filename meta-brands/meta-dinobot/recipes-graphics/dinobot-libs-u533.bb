SRCDATE = "20191025"

require dinobot-libs2.inc

SRC_URI[md5sum] = "5cd15b902bc437962494086515e849bd"
SRC_URI[sha256sum] = "3c147accc2f1e686b8227ef21aa313af79f80ee04744cdddc85421f4e0098b50"
