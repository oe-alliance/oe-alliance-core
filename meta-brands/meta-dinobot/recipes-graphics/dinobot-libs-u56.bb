SRCDATE = "20190415"

require dinobot-libs2.inc

SRC_URI[md5sum] = "54d1a1033a4c23361f84e43529f01053"
SRC_URI[sha256sum] = "5ef26ad528470b5428420627c8f2d6aad5ef101f2793fdcb83d3f14a7cabc5d5"
