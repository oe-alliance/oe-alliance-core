SRCDATE = "20191025"

SRC_URI[md5sum] = "edda81dc3e6c355fa2a8900d0b5a19bc"
SRC_URI[sha256sum] = "cab314addb31a41b43abbd6bdc92063db44c1d234feb11b8bdbfc07e2792a6ef"

require dinobot-blindscan.inc
