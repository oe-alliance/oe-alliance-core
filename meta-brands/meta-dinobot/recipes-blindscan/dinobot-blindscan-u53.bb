SRCDATE = "20191018"

SRC_URI[md5sum] = "85ad976a0a4eb93f6dc337ee325700db"
SRC_URI[sha256sum] = "b340730cd38dd59addb10c90efd45c3fb6ee41b97010a25266c4316ae9f5290b"

require dinobot-blindscan.inc
