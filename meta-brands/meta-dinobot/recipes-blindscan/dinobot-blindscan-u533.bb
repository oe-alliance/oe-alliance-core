SRCDATE = "20191021"

SRC_URI[md5sum] = "7530578990162ffe015e5e34c098d683"
SRC_URI[sha256sum] = "8fd58f8c37bb57a1112a53a25dd522e36cd2463141b9fa760b82dcc109b8c05b"

require dinobot-blindscan.inc
