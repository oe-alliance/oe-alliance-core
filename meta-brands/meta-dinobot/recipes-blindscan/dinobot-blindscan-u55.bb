SRCDATE = "20191011"

SRC_URI[md5sum] = "c0f4ec854010bd72f8b135067c28b485"
SRC_URI[sha256sum] = "cb89c2467d0830265210609f7c2b2d5c8a85771207f7ad4b0bf47977f532763e"

require dinobot-blindscan.inc
