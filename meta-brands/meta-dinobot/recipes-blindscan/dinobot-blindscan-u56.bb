SRCDATE = "20190428"

SRC_URI[md5sum] = "c3dcf3f086cb28047860634eced46628"
SRC_URI[sha256sum] = "bc3f027a1d827861db6179c7908931d7fc03b0d37322ba376b00e982207082f6"

require dinobot-blindscan.inc
