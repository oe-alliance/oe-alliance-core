SRCDATE = "20191018"

SRC_URI[md5sum] = "07077baecf4f92b9e9cbb8673457742c"
SRC_URI[sha256sum] = "0bacc458bd3d3ff12de9f8c2381220dd3e46cc264aa7689c9bbe39cef02cb9d5"

require dinobot-blindscan.inc
