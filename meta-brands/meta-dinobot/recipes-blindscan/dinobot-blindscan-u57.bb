SRCDATE = "20210604"

SRC_URI[md5sum] = "3d44cb0074b9a4cb5ab7af11c789731d"
SRC_URI[sha256sum] = "41fd44248b7eee6d3688b50a5633410cacde1da5a07be562332a8b51f6549deb"

require dinobot-blindscan.inc
