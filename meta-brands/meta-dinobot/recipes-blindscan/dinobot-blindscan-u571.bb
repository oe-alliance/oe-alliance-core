SRCDATE = "20210727"

SRC_URI[md5sum] = "adc0f054ba3746b3119d02376adb8bb2"
SRC_URI[sha256sum] = "f70518d29c8a3f64dc52a8639c17f6f621b59ce4cb20e9b8db49f86fc3cbd825"

require dinobot-blindscan.inc
