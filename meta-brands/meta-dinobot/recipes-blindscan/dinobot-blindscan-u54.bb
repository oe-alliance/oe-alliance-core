SRCDATE = "20191025"

SRC_URI[md5sum] = "f81c0a92adec207b65e92565ef2c56d2"
SRC_URI[sha256sum] = "03ef986cf48993f44755f6e17c46c7d4edfbbdde3ab1067545547f8276bb3e1e"

require dinobot-blindscan.inc
