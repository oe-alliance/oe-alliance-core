SRCDATE = "20191011"

SRC_URI[md5sum] = "503b0806a4336faf06dd79d76d365f90"
SRC_URI[sha256sum] = "3c2e358b633fb70a02962adb4c39a02a4177a93ecb68b3ef67d4ec6badaa873d"

require dinobot-blindscan.inc
