SRCDATE = "20191011"

SRC_URI[md5sum] = "1364cebacbff499674f137828174c640"
SRC_URI[sha256sum] = "cd83268632c09aebb1160d5b1ccf1bf042e19ee01081d8e4ce50437b0f4b0408"

require dinobot-blindscan.inc
