SRCDATE = "20191021"

SRC_URI[md5sum] = "d09f75ebcbbe1381dd3c018c4a1f515a"
SRC_URI[sha256sum] = "5df020d396ac049e0299996ec4281fcb145236d5674cf7603548b6fc3256f98b"

require dinobot-blindscan.inc
