
COMPATIBLE_MACHINE = "^(u5pvr)$"

SRCDATE = "20180928"
SRC_URI[md5sum] = "85f6efc8ae5926dcb6391e09a58b1fbf"
SRC_URI[sha256sum] = "1441e59ea5adb3577b8f6e7936cbffc249656d42a8fabc78033b37fc645e4548"

require dinobot-partitions.inc
