SRCDATE = "20210727"

SRC_URI[md5sum] = "6af49b1aa5f407da7d5201171d6600d5"
SRC_URI[sha256sum] = "cf9315b7fb481cf0144d764253bf1531b05d8d45634b7ef0c57f97ce3becb561"

require dinobot-hihalt.inc
