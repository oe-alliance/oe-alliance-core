SRCDATE = "20191018"

SRC_URI[md5sum] = "dad62ed8f5bc372447f2548c2283ef47"
SRC_URI[sha256sum] = "59d656804f10ace9e7f598016b29758d277c7cf8649c5f7bb0187403e5454260"

require dinobot-hihalt.inc
