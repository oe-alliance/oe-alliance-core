SRCDATE = "20190715"

SRC_URI[md5sum] = "2a1fb02bcf69067988290cfb4e951517"
SRC_URI[sha256sum] = "141537998be717e29d8657d9dd867c425464c9f3d599c4787d3e8e208227145e"

require dinobot-hihalt.inc
