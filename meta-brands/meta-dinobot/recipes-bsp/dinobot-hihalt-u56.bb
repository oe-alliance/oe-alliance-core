SRCDATE = "20190415"

SRC_URI[md5sum] = "99e7fb74c1fbe3c81ec8edb0567a8d0b"
SRC_URI[sha256sum] = "28e995f2f509b40aba815ff71ef6e583f1222ff69bd090db78390a7704db775f"

require dinobot-hihalt.inc
