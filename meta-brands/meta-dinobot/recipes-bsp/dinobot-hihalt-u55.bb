SRCDATE = "20191011"

SRC_URI[md5sum] = "f3fce343758dbeba74a943638bdc15cd"
SRC_URI[sha256sum] = "e99cb1463332222fafcff2fe46637e79e899d76a7b72d6bc323ea1a18fa08445"

require dinobot-hihalt.inc
