SRCDATE = "20191011"

SRC_URI[md5sum] = "0910360daa5276481b5018e338dd827d"
SRC_URI[sha256sum] = "61fd9ce6ff0e80f8baf963dbcf026d851402443ff94fc6fe395e2e0f7aea71fe"

require dinobot-hihalt.inc
