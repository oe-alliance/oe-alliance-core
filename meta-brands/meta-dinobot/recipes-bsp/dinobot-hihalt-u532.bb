SRCDATE = "20191025"

SRC_URI[md5sum] = "0bdb74df2fae14847c0121fdedae9e26"
SRC_URI[sha256sum] = "53416274f3676a6cd6e85586eda1021402c94e7673356870bfe920581aa8f81d"

require dinobot-hihalt.inc