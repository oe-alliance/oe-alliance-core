SRCDATE = "20191025"

SRC_URI[md5sum] = "ba7d2e9d1276544509d31f2ea4554107"
SRC_URI[sha256sum] = "058ce57e87c3a50f83dce471244025d3e1cc44a1226fcc37fa2c6d69a9bd62fd"

require dinobot-hihalt.inc
