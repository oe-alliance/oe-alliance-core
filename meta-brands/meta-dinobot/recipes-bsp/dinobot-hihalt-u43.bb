SRCDATE = "20190729"

SRC_URI[md5sum] = "876a6dcee7259d8b6ea661cdd9785090"
SRC_URI[sha256sum] = "bd6609ac667460480060f10adc304a102a7e88fb7d3f6bb3484b7221582e8a59"

require dinobot-hihalt.inc
