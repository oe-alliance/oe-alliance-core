SRCDATE = "20211109"

SRC_URI[md5sum] = "031c3d8481bbdddb13c62792bd8a4e5a"
SRC_URI[sha256sum] = "672845b3d17450135dff49f1cc2768bd06a46847476f3daab2758fe9e94bd01a"

require dinobot-hihalt.inc
