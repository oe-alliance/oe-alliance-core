SRCDATE = "20210604"

SRC_URI[md5sum] = "8a7e302e45660c2e5aa1e5680bffc64d"
SRC_URI[sha256sum] = "a471eb318a86d5534e36442835831020e3118d20d278a28b2007070b1de34227"

require dinobot-hihalt.inc
