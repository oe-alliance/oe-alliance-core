SRCDATE = "20190718"

SRC_URI[md5sum] = "523fb555b48f5dfc0ad387f2c3ce610c"
SRC_URI[sha256sum] = "123227cf28fac9afc888c4e751e3174dd54564a7387f07de4f4335b2200bb15d"

require dinobot-hihalt.inc