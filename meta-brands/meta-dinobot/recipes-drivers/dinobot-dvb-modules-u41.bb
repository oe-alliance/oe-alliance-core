KV = "4.4.35"
SRCDATE = "20190627"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "f7f91c93db51a7720bc6fee30b818d04"
SRC_URI[sha256sum] = "ecbbfe56b1f7dad99e159ee13106c6d43b199ca32a1d7a62637f42379acfdc78"
