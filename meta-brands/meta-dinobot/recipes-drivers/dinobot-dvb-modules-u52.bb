KV = "4.4.35"
SRCDATE = "20191018"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "f57a76165b0a52601299e27fc09878e8"
SRC_URI[sha256sum] = "55a5881475f2fdfad77dbfb579730039eaefe0cfa2d3b8cb56dc31e87df798ff"
