KV = "4.4.35"
SRCDATE = "20210604"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "6c85606e92a4cc0f0b0418168141a947"
SRC_URI[sha256sum] = "90be28cc6b8dbad9997afea9dde4bd53fce73f0b1ee2f7f805d5d416012e9590"
