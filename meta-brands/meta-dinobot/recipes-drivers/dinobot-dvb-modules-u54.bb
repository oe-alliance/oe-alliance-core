KV = "4.4.35"
SRCDATE = "20191025"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "6eab6fed5754d57523805e72b7906f7b"
SRC_URI[sha256sum] = "a9cc88d60de3204900f69fa66f2d38c4ba766823edfe7392273f25a8c566ce95"
