KV = "4.4.35"
SRCDATE = "20191012"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "e7210b3e972f5554d5af3402440b1762"
SRC_URI[sha256sum] = "4c84a1a2dda85d3e93e6a6e98498065396b6c4a0db9f98e671af0d301b52b98c"
