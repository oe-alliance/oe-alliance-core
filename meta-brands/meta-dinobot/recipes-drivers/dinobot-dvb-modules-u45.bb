KV = "4.4.35"
SRCDATE = "20211109"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "5a94d686e47fad974a95c72f2a51d246"
SRC_URI[sha256sum] = "e292ce854fb099c4296178c7c0470f32de1ce6df7580de3bfe07760c588201e8"
