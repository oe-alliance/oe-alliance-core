KV = "4.4.35"
SRCDATE = "20210727"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "b3d6866bf8d5dd879bf998c38aa19075"
SRC_URI[sha256sum] = "484770c76153a821d62489eb08fd2c3f65c9e9153de39d464c09768181b7137c"
