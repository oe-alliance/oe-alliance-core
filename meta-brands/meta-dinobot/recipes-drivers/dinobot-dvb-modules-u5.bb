KV = "4.4.35"
SRCDATE = "20191025"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "b8560f17ea50211eb753b04697d89782"
SRC_URI[sha256sum] = "5f30ba89a9e882262a90f4fb2c0d9f49dbbc8881e2654453fe663d49b6ed926b"
