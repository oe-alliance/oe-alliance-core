KV = "4.4.35"
SRCDATE = "20180905"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "f9b3b761d61a799dd304dee59b90cc77"
SRC_URI[sha256sum] = "2ce9e88917ae8d7f46f0d5ffe9234a07ffd40f8514dd6325583ca43f4e7ff9f4"
