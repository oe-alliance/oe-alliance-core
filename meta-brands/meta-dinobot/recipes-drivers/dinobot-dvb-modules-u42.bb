KV = "4.4.35"
SRCDATE = "20190715"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "483b8bfb6373f201bb013f711eb4e36b"
SRC_URI[sha256sum] = "ef5d61b61a80c2ba696265ac2bff999b56aab6e87b08634c0981c7863b609dc6"
