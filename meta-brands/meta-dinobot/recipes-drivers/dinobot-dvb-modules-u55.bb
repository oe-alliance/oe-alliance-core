KV = "4.4.35"
SRCDATE = "20191209"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "b2bbdebd0ec806dc5526a6228f6e8cca"
SRC_URI[sha256sum] = "563e8a2c0ad9d0594307caef16faf34f9298b72fdd0b12b7043355c1bb2e3acd"
