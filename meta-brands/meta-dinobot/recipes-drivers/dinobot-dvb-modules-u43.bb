KV = "4.4.35"
SRCDATE = "20190620"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "3177391669fa899ce5d9300556c5e14d"
SRC_URI[sha256sum] = "b0244f7eba53f71e674aca34cd3708c9d5d94031013b6574b688f74cbe41e982"
