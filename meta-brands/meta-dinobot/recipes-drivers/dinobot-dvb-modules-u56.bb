KV = "4.4.35"
SRCDATE = "20190415"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "eae72d9730813639c03244a72470d7f6"
SRC_URI[sha256sum] = "053bea15f4e635ef0056f4e771b4a1645b21a5810f9d9ad7e967d60ffe59944c"
