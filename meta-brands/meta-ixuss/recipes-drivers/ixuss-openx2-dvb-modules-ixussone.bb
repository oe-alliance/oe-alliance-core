KV = "3.3.0"
SRCDATE = "20130319"

require ixuss-openx2-dvb-modules.inc

DOWNLOADMACHINE = "one"

SRC_URI[md5sum] = "9dd7bca613fb210e6380ea7cafc1f6d3"
SRC_URI[sha256sum] = "718d6fdbd94f38fae9470c247d590d14e552a0541893731c02e88b88705044b9"

