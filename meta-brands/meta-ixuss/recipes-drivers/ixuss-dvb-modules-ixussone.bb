KV = "3.3.0"
SRCDATE = "20141013"

require ixuss-dvb-modules.inc

DOWNLOADMACHINE = "one"

SRC_URI[md5sum] = "17b9002f924bfecbe8648147eb4892d1"
SRC_URI[sha256sum] = "82bc1b5214ae243cad93fe17a0fe9e0783131da292cf93087962bbfa4de02382"

