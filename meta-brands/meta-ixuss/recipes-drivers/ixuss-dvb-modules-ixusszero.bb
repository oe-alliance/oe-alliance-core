KV = "3.3.0"
SRCDATE = "20141006"

require ixuss-dvb-modules.inc

DOWNLOADMACHINE = "zero"

SRC_URI[md5sum] = "e8765d4cea6c3d15882aa80c6d76944c"
SRC_URI[sha256sum] = "acecdd5580a9c9811b9a5021d60d8c8ed4dcb229bd5ab6c254d33c9bdf5f9cb9"

