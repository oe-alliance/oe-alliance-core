KV = "3.14.2"
SRCDATE = "20140831"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "5e0ae534a36122930b76a019dc66d7f3"
SRC_URI[sha256sum] = "df486a44c58448afc0dcba54d0b935f296bb6b8c411e68dd8d9adcaf3874dd27"
