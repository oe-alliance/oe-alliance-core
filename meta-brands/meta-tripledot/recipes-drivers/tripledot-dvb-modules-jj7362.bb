KV = "3.14.2"
SRCDATE = "20160302"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "d02e5f4c96246ff060e63b5c77d96ca4"
SRC_URI[sha256sum] = "724ed2df861530c3833ccbcc494d2bac48268e96ac285b324c57e9fd793c4dee"
