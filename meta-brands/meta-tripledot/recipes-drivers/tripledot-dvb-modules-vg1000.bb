KV = "3.14.2"
SRCDATE = "20160302"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "df5bf115da3c94ad6850c0da80e81c8f"
SRC_URI[sha256sum] = "208ca57285104e712011a5edc5d12782e32cd7bce91d85ce0dcf6eddbb572be6"
