KV = "3.14.2"
SRCDATE = "20160305"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "0ff6534bb1278ec492c9373863eecf23"
SRC_URI[sha256sum] = "88b872b238c5d2d8ea5211430d8455a778f7e2e3b030cd437b44dbfa1df35ab5"
