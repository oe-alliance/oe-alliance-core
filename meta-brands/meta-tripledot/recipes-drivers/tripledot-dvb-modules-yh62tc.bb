KV = "3.14.2"
SRCDATE = "20170821"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "114e38231a988d81cc54635f8f0fd8fc"
SRC_URI[sha256sum] = "5ded8c44054d10639097d2c89ba1df262a503d6505bce2e69b3cf7c5ddea4b1c"
