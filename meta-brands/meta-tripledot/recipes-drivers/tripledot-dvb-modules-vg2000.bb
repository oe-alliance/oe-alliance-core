KV = "3.14.2"
SRCDATE = "20160302"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "008219e6657702526b591b02b0e50bfb"
SRC_URI[sha256sum] = "ed9bcba9b0d527e99b09e87db05f064aa62cb8eb67a43f8c4dac0d0e16c9142f"
