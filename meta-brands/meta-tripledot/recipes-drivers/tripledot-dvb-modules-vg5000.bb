KV = "3.14.2"
SRCDATE = "20160302"

require tripledot-dvb-modules.inc
SRC_URI[md5sum] = "309f416c18ad3e386f26c02425c88465"
SRC_URI[sha256sum] = "adbfbd578023495a088dbeab7737636ce906a15893ceccb5fd5749563109137d"
