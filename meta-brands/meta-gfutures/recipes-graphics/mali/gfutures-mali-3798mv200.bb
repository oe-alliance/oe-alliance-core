SRCDATE = "20181201"

require gfutures-mali-utgard.inc

SRC_URI[md5sum] = "19aacdd98123f4aedeaf6d25dceddc8c"
SRC_URI[sha256sum] = "2e799131fa28ea98c92f3bf2e5a24b5ee93bd09812a0ce1a848911d2e6c5bc15"
COMPATIBLE_MACHINE = "(hd60|hd61|hd66se)"
