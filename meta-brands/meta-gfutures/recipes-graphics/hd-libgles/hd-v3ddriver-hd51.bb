SRCDATE = "20170310"

require hd-v3ddriver.inc

SRC_URI[md5sum] = "8bf2e5e7d3bdd3a78d04a0bce5575a02"
SRC_URI[sha256sum] = "79d438cf1d645e9726d0122f77f304ea7d8b6ade9d4177f1a5492906d9169ff9"

COMPATIBLE_MACHINE = "hd51"