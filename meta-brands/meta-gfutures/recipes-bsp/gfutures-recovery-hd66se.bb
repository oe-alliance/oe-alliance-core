SRCDATE = "20211208"

require gfutures-recovery.inc

SRC_URI[md5sum] = "f1943b14e1056d151191e0feed141f0c"
SRC_URI[sha256sum] = "fc1a98fef44e15b9b1b2aa6b490d3fa759e8144f82ff90dc50c648dd4f34b3c6"

COMPATIBLE_MACHINE = "hd66se"
