SRCDATE = "20190103"

require gfutures-bootargs.inc

SRC_URI[md5sum] = "7476bb1d1079aa0e128eb70711409e10"
SRC_URI[sha256sum] = "3c59fe4aef9218671743f0e32f5e07b29e4940527d27924ac8b0371a07222cbd"

COMPATIBLE_MACHINE = "hd60"