SRCDATE = "20181201"

require gfutures-libs.inc

SRC_URI[md5sum] = "8fa941790f938731f71aeabea0c87049"
SRC_URI[sha256sum] = "abf6bd855a221b8768514a99df58df059e28e64e7849a9108ca46d077cd3a8a7"

COMPATIBLE_MACHINE = "(hd60|hd61)"
