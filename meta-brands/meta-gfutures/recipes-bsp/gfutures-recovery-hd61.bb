SRCDATE = "20191020"

require gfutures-recovery.inc

SRC_URI[md5sum] = "c919d7ca29897bc18423707a5cf7e449"
SRC_URI[sha256sum] = "4d089ff0c981981793bf6af7e5633c2d2e6f74b2a5b1e2a8e7f76b15f898c00a"

COMPATIBLE_MACHINE = "hd61"
