SRCDATE = "20220208"

require gfutures-partitions.inc

SRC_URI[md5sum] = "ab0b645a5580e6fe2f4fbd8d6a6948c8"
SRC_URI[sha256sum] = "603cc281b606d8fba4fb081cc9015395c84314b7cc364e2d8d1c97b7e7408536"
 
COMPATIBLE_MACHINE = "hd66se"
