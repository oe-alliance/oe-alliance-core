SRCDATE = "20220208"

require gfutures-bootargs.inc

SRC_URI[md5sum] = "67736c07387b606c2b524723aea87d40"
SRC_URI[sha256sum] = "c98debb775b713fdc493fe67f0bef169ac2e7ec7a21273ac762fda2fe4a29cf5"

COMPATIBLE_MACHINE = "hd66se"