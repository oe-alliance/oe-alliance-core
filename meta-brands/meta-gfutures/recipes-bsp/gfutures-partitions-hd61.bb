SRCDATE = "20191020"

require gfutures-partitions.inc

SRC_URI[md5sum] = "7ccb4386fc07f7849aec2d0e56322fba"
SRC_URI[sha256sum] = "f15b1fdb5e9de9331e3fb6408f3eca234afe581e68c88d4981bed5f050832881"

COMPATIBLE_MACHINE = "hd61"
