SRCDATE = "20170216"

require hd-v3ddriver.inc

SRC_URI[md5sum] = "008b4e8ba96317e5117acb4d0a3ea7bf"
SRC_URI[sha256sum] = "1663121cf9cf6e17298ee49dc135e5af26fd8d179ad6b7bd56ebdeeeb82f2cba"

COMPATIBLE_MACHINE = "hd51"