SRCDATE = "20180912"

require gfutures-libs.inc

SRC_URI[md5sum] = "d46a8ef06966f80a012808798b442112"
SRC_URI[sha256sum] = "91955713be85fb6cceefd093d700eebfdcab8d0fe6deb30e20de15f9642657d6"

COMPATIBLE_MACHINE = "hd60"