SRCDATE = "20191020"

require gfutures-bootargs.inc

SRC_URI[md5sum] = "3d748cb68915435540df4a27ad07fa67"
SRC_URI[sha256sum] = "162eb18ec92bce715832c152932478fe436c4ce83bce017cf80641c5709a7b93"

COMPATIBLE_MACHINE = "hd61"
