KV = "4.0.1"
SRCDATE = "20160902"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "64cbd41c08cca32e42bddc3ead7f3434"
SRC_URI[sha256sum] = "2a90774fc3419941f3d70295dee87de454ceaf637d7ebbabe16b8a454f239dbc"