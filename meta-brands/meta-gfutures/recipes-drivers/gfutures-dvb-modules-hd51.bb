KV = "4.10.12"
SRCDATE = "20250429"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "5345c90fe47bff97fbedb162551d3637"
SRC_URI[sha256sum] = "ab8dc65d8260ddc72e5744ed4a917b40297dbe75ce16efef09c4e8d455d1a613"
