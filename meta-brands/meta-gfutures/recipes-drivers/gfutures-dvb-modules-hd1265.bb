KV = "4.7.3"
SRCDATE = "20160921"

require gfutures-dvb-modules.inc
SRC_URI[md5sum] = "a466e98a70e5f64ca89587c0a2488821"
SRC_URI[sha256sum] = "a171a33831453585aee37abce5aea8359040dd44a67f12dde4808274af695bf1"
