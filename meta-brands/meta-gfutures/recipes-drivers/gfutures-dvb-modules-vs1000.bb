KV = "4.7.6"
SRCDATE = "20170112"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "705adf52656041d20097ae8e3a3796e0"
SRC_URI[sha256sum] = "82480bcd107ff994491fb13862ef712576c9bc4611812e850a589fd2a538c805"
