KV = "4.7.3"
SRCDATE = "20160921"

require gfutures-dvb-modules.inc
SRC_URI[md5sum] = "c8153cd5412eb89deede9468d31a24a8"
SRC_URI[sha256sum] = "8596d06734d0c0838acf42e5ba70b52845342b338f08da4273274af27c476ef0"
