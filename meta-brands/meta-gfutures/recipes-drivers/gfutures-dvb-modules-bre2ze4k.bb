KV = "4.10.12"
SRCDATE = "20250429"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "f4e428b74d52d47b40fffbc008103bdc"
SRC_URI[sha256sum] = "001026054a16a976d6e52c5aa187a6f39f5b6ddaa5f5ca1bb57f0e41e76af710"
