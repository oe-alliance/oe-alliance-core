KV = "4.7.3"
SRCDATE = "20160921"

require gfutures-dvb-modules.inc
SRC_URI[md5sum] = "09ec6010dbc8b7ec7cb1a1e0576e747d"
SRC_URI[sha256sum] = "e90153025f40b8b1ccf6cda2637e664cf01baaaa694432c3e4a52dd7dd3decef"
