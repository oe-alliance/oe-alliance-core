KV = "4.10.12"
SRCDATE = "20250429"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "13606a5cc4cc8067fb91b37cf0399428"
SRC_URI[sha256sum] = "292383c603f0c2bd02fb1643a8afef48fe8c1f7c1ec4eb72f75cf6fa2e707b77"
