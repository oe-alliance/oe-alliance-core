KV = "4.7.3"
SRCDATE = "20160921"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "10da12aaaa512b2e8cc5a020068eea7a"
SRC_URI[sha256sum] = "7667a440477d3a986c65dde02c2c2fc6e5d97b3cea9659896f84a6e2498ee8c8"
