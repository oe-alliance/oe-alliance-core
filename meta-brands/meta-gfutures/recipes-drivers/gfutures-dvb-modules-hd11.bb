KV = "4.0.1"
SRCDATE = "20160603"

require gfutures-dvb-modules.inc
SRC_URI[md5sum] = "2495721db585a931c5bcf11f653fb567"
SRC_URI[sha256sum] = "62ed4d35c56a1b9d9328bcd58924b67318fe11b9dd5919996e438463c5b4b084"
