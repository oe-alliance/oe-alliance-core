KV = "4.7.3"
SRCDATE = "20160921"

require gfutures-dvb-modules.inc
SRC_URI[md5sum] = "41fb882e69986d1da8596002c74b68cf"
SRC_URI[sha256sum] = "1dbb2fa67ca7e48576829e09a7a6393c293b83bf0e296dc807ddc71755d2c8b3"
