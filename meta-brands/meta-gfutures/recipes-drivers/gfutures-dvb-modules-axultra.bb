KV = "4.10.12"
SRCDATE = "20250429"

require gfutures-dvb-modules.inc

SRC_URI[md5sum] = "4e3775fa6cab1bb0a6f2a7ba6bf26229"
SRC_URI[sha256sum] = "8925e100c168821d0027b51d2885d001d6fece99a1c39a1c4ba2e6c1807ae43b"
