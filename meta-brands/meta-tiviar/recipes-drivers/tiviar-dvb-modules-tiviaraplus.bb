KV = "4.10.6"
SRCDATE = "20171022"

require tiviar-dvb-modules-al.inc
SRC_URI[md5sum] = "6fd0ccdb3e114d68d3c69b8915ca2916"
SRC_URI[sha256sum] = "7bda65f23416b888f8ce853e2e196a6b7c9f7de6049414397536c82602b2f81d"
