KV = "4.7.6"
SRCDATE = "20170124"

require tiviar-dvb-modules.inc
SRC_URI[md5sum] = "d209a84b55fbda693c0b3b8a499e2b0a"
SRC_URI[sha256sum] = "b811fcc46dd70a2ef8a1d7f1bad81c1d14f5c6eb60ea9aad8e00f2e0f5a07f52"
