require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "d0e198bd18605efa11d7a97b18d7ff16"
SRC_URI[modules.sha256sum] = "98504de2f5adedb4886d04ce907292dcf82306e195d6ba51b3644c92aeac0192"