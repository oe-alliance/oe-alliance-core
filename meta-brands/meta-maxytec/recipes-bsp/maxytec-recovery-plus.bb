SRCDATE = "20200624"

require maxytec-recovery.inc

SRC_URI[md5sum] = "a66e1b0664afb2aa15ae6db709a6dcc9"
SRC_URI[sha256sum] = "5340b958855578af59e0fd1dc8772c9f98927978fe4d15d9dfbfa926b4aead59"

COMPATIBLE_MACHINE = "plus"
