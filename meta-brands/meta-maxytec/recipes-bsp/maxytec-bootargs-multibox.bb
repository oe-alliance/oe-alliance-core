SRCDATE = "20190204"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "937b8fd9c00dcd32bbf071d67d3d4993"
SRC_URI[sha256sum] = "b806d8c79cd3e260af7b0d2a0652b65a8b3be4b7e18dddda12b80bc0e62a46c1"

COMPATIBLE_MACHINE = "multibox"