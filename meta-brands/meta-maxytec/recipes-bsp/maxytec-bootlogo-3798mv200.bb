SRCDATE = "20200630"

require maxytec-bootlogo.inc

SRC_URI[md5sum] = "241bff3016f447ab7b0cd9cb7c096105"
SRC_URI[sha256sum] = "b0ba3c4a3bbde9506b5e1db9e231c3480cce0e59f3ba81c40c761c4113021b22"

COMPATIBLE_MACHINE = "multibox|plus"