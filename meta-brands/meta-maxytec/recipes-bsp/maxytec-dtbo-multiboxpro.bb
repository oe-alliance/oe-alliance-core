SRCDATE = "20221130"

require maxytec-dtbo.inc

SRC_URI[md5sum] = "799b02df5702fbf0d692a97b00e6e3da"
SRC_URI[sha256sum] = "94286dc0cc2551015640b550bb385cdb1f5aafcbbf5be3ada8c71cde2dc7e778"

COMPATIBLE_MACHINE = "multiboxpro"
