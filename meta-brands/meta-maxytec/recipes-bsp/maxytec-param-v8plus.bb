SRCDATE = "20190104"

require maxytec-param.inc

SRC_URI[md5sum] = "f64abb79cbb3aee616ee0e09302a82b6"
SRC_URI[sha256sum] = "b83b2f73394ee2b0e8720e325eb042ca242589df28ba08b12dafc7a2dc3c1b94"

COMPATIBLE_MACHINE = "v8plus"