SRCDATE = "20190104"

require maxytec-bootlogo.inc

SRC_URI[md5sum] = "18115d2d982ea59803d98334f0f6aa8f"
SRC_URI[sha256sum] = "112815b8aa7a913e91b9be8209cc26131d6687b92183474dac6b9f1b15661efb"

COMPATIBLE_MACHINE = "multibox"