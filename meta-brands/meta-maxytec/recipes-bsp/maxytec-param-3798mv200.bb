SRCDATE = "20200630"

require maxytec-param.inc

SRC_URI[md5sum] = "29e396cc5772f1b14b6b59acc1175e8f"
SRC_URI[sha256sum] = "f07fd9707db934cdb192312ab251e9ea7120563714a9de36f7d3cec8ac2643a4"

COMPATIBLE_MACHINE = "multibox|plus"