SRCDATE = "20221130"

require maxytec-dtbo.inc

SRC_URI[md5sum] = "aeb552863a43712e8bd60a9b88d1621a"
SRC_URI[sha256sum] = "febe9939a1f37f86d7338e1bdc90eca6df7c9643b65115c0d9f953e8f77b92ca"

COMPATIBLE_MACHINE = "multiboxse"
