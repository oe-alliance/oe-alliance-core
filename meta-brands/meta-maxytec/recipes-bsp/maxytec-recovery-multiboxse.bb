SRCDATE = "20201110"

require maxytec-recovery.inc

SRC_URI[md5sum] = "d56554c671af68ebae94d05f94fdf179"
SRC_URI[sha256sum] = "c868d602784ca8563fac11592dc72806de6cb3e68a743f4146b58a88f4b75a11"

COMPATIBLE_MACHINE = "multiboxse"
