SRCDATE = "20200630"

require maxytec-fastboot.inc

SRC_URI[md5sum] = "2e3725c3dfb3812e177ff9f9b6439e4b"
SRC_URI[sha256sum] = "b71ca39843776b19067fe3d0296658e8bc697b99701037d169d261d2965507f5"

COMPATIBLE_MACHINE = "plus"