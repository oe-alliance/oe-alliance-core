SRCDATE = "20201110"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "729b729d069b56e51dd971551e842b96"
SRC_URI[sha256sum] = "7391746e710ca1f58f86c0a58f25e9a54494e3c3c84c1aeb1218cfa5a37832ce"

COMPATIBLE_MACHINE = "multiboxse"
