SRCDATE = "20190329"

require maxytec-recovery.inc

SRC_URI[md5sum] = "a141ea4530e46c0f7aa2c5f7ee65216d"
SRC_URI[sha256sum] = "9bbc3f18159267615a6899fe31fb272a325f51d319386480fdd5fd72eab425b2"

COMPATIBLE_MACHINE = "multibox"
