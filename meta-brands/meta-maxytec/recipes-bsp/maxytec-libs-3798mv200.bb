SRCDATE = "20200504"

require maxytec-libs.inc

SRC_URI[md5sum] = "6f2febe8b2f2230a6d9ea550561b5fa6"
SRC_URI[sha256sum] = "f0ece4c9c62ab53cf7b16be9aa9c927697cbaa2a04ecb3e29e658fb388f32de6"

COMPATIBLE_MACHINE = "v8plus|multibox"
