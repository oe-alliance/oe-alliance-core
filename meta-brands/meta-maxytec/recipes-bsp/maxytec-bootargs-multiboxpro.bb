SRCDATE = "20221130"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "5c38e55cb9a3d1c639440c217c9965d7"
SRC_URI[sha256sum] = "4317a5d335c59c2224594e21df379efd7919c5b5da96408bd346c46070ea354a"

COMPATIBLE_MACHINE = "multiboxpro"
