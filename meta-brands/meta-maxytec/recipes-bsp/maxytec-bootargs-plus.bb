SRCDATE = "20200630"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "a62727bda678ddfa590b43848b3fd69c"
SRC_URI[sha256sum] = "fdddd597296f909154dd4bc99ffe21b3e0efd1ddfd13c27781a83db5246414b9"

COMPATIBLE_MACHINE = "plus"