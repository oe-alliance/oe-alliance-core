SRCDATE = "20190104"

require maxytec-bootlogo.inc

SRC_URI[md5sum] = "dfc87361e22429d50c1417ab4873da5e"
SRC_URI[sha256sum] = "ce679949e972e674b6ede6f9bc36b0ffdb46094632b84f4dc5c668b9c0156e98"

COMPATIBLE_MACHINE = "v8plus"