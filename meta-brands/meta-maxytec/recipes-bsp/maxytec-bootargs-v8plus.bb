SRCDATE = "20190104"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "3f07c39c53ab53c881a71ed7ad9c3566"
SRC_URI[sha256sum] = "c631cb7ceaea6d9090440b294a0ace0ad791672b00675228583bdd1f54a874b8"

COMPATIBLE_MACHINE = "v8plus"