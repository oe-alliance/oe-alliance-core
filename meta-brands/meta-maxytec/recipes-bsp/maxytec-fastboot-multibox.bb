SRCDATE = "20190204"

require maxytec-fastboot.inc

SRC_URI[md5sum] = "3bcd96badca987853a9253d15396d1ee"
SRC_URI[sha256sum] = "3010b1f95338d444ece30ae25d067c146dfcedc56558df6b9b764154222cdb82"

COMPATIBLE_MACHINE = "multibox"