SRCDATE = "20221130"

require maxytec-dtbo.inc

SRC_URI[md5sum] = "28e254ff6dda39c9c3394089d58a82c3"
SRC_URI[sha256sum] = "85698b07c3ae75b6bfe273b018c2e3d0fe0b45861872e5ae1321b20ced400229"

COMPATIBLE_MACHINE = "multibox"
