SRCDATE = "20190104"

require maxytec-param.inc

SRC_URI[md5sum] = "0fdda79cce8718356aa3fd9d8a5d2a75"
SRC_URI[sha256sum] = "7b22b29cf488fe6c024a575bac5f64f271e09b1418fc187a70a758516b20558a"

COMPATIBLE_MACHINE = "multibox"