SRCDATE = "20221130"

require maxytec-recovery.inc

SRC_URI[md5sum] = "b9a36c8289cbed25aa412dc16523158f"
SRC_URI[sha256sum] = "eee0100aa71c85e89fe4f7598368743bd470ddbc36ad41e2f8bbe81bc3e56cc5"

COMPATIBLE_MACHINE = "multiboxpro"
