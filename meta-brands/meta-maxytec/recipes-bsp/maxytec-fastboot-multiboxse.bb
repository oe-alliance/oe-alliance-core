SRCDATE = "20201110"

require maxytec-fastboot.inc

SRC_URI[md5sum] = "f919daaddc877fe9a82a34c2cb62aea5"
SRC_URI[sha256sum] = "45a99f3e0dbe26cd7df52fa867be789127e58a588df7120c504f7921f11b239c"

COMPATIBLE_MACHINE = "multiboxse"
