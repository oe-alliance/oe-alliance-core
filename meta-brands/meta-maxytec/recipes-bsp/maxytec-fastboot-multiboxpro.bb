SRCDATE = "20221130"

require maxytec-fastboot.inc

SRC_URI[md5sum] = "6b78af0a53d09097cf47feddae9f3cef"
SRC_URI[sha256sum] = "327550e857e37c27b29c64319dc7d907377ac48f03d75b4d167fea58d25de61e"

COMPATIBLE_MACHINE = "multiboxpro"
