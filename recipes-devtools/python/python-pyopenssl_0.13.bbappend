PRINC = "1"

include python-package-split.inc
