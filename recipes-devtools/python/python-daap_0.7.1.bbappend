PRINC = "1"

SRC_URI += " \
	file://python-daap.patch \
"
