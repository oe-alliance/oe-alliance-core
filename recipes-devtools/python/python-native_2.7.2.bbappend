PRINC = "3"

RPROVIDES_${PN} += "python-pickle-native python-pprint-native"
