PRINC = "1"
SYSTEMD_PACKAGES = "${PN}-systemd"
