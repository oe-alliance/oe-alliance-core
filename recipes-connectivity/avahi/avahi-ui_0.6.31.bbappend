PRINC = "1"

AVAHI_GTK_append = " --enable-python"

FILES_python-avahi = "${libdir}/python2.7/site-packages/avahi/*"

