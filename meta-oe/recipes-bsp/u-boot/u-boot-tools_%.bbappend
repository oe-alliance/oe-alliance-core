FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://openssl40-no-engine.patch"
BUILD_CFLAGS += "-DCONFIG_OPENSSL_NO_DEPRECATED"
TARGET_CFLAGS += "-DCONFIG_OPENSSL_NO_DEPRECATED"
