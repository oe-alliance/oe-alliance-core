SUMMARY = "Parser for multipart/form-data"
HOMEPAGE = "https://multipart.readthedocs.io/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5839ff44e4664f433e332b0cac1e534a"

SRC_URI[md5sum] = "ec16f14baa2132c6552e3f816717ebf4"
SRC_URI[sha256sum] = "a46bd6b0eb4c1ba865beb88ddd886012a3da709b6e7b86084fc37e99087e5cf1"

inherit pypi python_setuptools_build_meta
