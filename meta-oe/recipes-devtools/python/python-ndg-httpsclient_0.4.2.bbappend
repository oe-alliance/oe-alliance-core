DEPENDS += " python-setuptools-native"