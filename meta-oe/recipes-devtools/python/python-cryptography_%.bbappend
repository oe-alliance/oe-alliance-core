CFLAGS_append = " -pthread"

include python-package-split.inc

