RDEPENDS:${PN} += "python3-cssselect"

include python3-package-split.inc
