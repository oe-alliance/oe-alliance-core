require ${PYTHON_PN}-package-split.inc
