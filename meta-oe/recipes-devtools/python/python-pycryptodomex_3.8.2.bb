inherit setuptools
require ${PYTHON_PN}-pycryptodomex.inc
