SUMMARY = "Parser for multipart/form-data"
HOMEPAGE = "https://multipart.readthedocs.io/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5839ff44e4664f433e332b0cac1e534a"

SRC_URI[md5sum] = "241d8e2b408e65634e05fc74d23552ad"
SRC_URI[sha256sum] = "211d7cfc1a7a43e75c4d24ee0e8e0f4f61d522f1a21575303ae85333dea687bf"

inherit pypi python_setuptools_build_meta
