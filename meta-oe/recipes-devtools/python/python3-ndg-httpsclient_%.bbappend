DEPENDS += "python3-setuptools-native"
include python3-package-split.inc
