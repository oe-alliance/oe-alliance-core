require python-package-split.inc
