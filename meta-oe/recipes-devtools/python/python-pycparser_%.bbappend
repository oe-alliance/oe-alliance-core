RDEPENDS_${PN}_remove =  "cpp cpp-symlinks"

include ${PYTHON_PN}-package-split.inc
