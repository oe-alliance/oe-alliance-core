export AUTOBAHN_USE_NVX
AUTOBAHN_USE_NVX = "0"

include python3-package-split.inc
