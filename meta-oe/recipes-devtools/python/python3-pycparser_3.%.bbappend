RDEPENDS:${PN}:class-target:remove = "\
	cpp \
	cpp-symlinks \
"
