DEPENDS += "python3-wheel-native"

include python3-package-split.inc
