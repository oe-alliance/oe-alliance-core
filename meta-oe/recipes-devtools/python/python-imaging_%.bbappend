include python-package-split.inc
RDEPENDS_${PN}_remove = "dinobot-libs-${MACHINE}"
