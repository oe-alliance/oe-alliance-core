inherit setuptools3_legacy

include python3-package-split.inc
