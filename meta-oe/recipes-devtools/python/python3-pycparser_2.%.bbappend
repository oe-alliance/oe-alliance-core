RDEPENDS_${PN}_class-target_remove = "\
	cpp \
	cpp-symlinks \
"
