RDEPENDS_${PN} = "python-cssselect"

include python-package-split.inc
