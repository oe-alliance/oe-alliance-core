include python3-package-split.inc

TARGET_CFLAGS:append = " -flax-vector-conversions"
