PACKAGES =+ "${PN}-test"

include python3-package-split.inc
