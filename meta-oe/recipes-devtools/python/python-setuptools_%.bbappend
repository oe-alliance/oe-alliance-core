FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

include python-package-split.inc
