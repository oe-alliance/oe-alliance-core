DEPENDS += "python-setuptools-native"

include python-package-split.inc
