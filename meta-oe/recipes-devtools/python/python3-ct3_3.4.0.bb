SUMMARY = "Cheetah is a template engine and code generation tool"
HOMEPAGE = "https://cheetahtemplate.org/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6c8d05debf9d3d283931051ce5232fe7"

SRC_URI[sha256sum] = "ddc493b775b02b09737b1fb628a973dbe9aa91d694045a6764a8e3f5296fa1eb"

inherit pypi python_setuptools_build_meta

