RDEPENDS_${PN} += "libusb1"

include python-package-split.inc
