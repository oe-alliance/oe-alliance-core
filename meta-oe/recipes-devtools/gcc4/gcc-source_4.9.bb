require recipes-devtools/gcc4/gcc-${PV}.inc
require recipes-devtools/gcc4/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"
