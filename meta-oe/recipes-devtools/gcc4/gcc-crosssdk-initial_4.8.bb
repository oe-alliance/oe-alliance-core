require recipes-devtools/gcc4/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc

