require recipes-devtools/gcc4/gcc-cross_${PV}.bb
require gcc-crosssdk.inc
