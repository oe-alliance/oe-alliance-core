require recipes-devtools/gcc4/gcc-${PV}.inc
require libgfortran.inc

