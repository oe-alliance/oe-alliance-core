require recipes-devtools/gcc4/gcc-${PV}.inc
require gcc-cross-canadian.inc



