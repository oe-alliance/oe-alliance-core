do_install:append () {
    rm -rf ${D}${libdir}/tcl9.0/tzdata
}
