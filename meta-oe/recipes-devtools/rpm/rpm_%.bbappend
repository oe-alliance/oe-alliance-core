FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://gcc6-stdlib.patch"
