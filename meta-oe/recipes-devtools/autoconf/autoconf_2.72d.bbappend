FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://autoheader-nonfatal-warnings.patch"
