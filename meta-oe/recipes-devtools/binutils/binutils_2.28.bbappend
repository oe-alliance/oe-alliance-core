SRC_URI += " \
	file://1001-do-not-set-the-ABIVERSION-to-5-for-MIPS.patch \
	"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
