PACKAGE_NO_LOCALE = "1"

EXTRA_OECONF:append = " --disable-gprofng"
GPROFNGS = ""
