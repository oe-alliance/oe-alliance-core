# we use openssl 1.0.2
SRC_URI_remove = "file://core/adb_libssl_11.diff;patchdir=system/core"
