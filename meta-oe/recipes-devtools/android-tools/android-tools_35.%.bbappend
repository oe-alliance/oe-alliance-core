FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0012-libziparchive-include-cstdint-in-zip_writer.h.patch"
