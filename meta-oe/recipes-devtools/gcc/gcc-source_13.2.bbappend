FILESEXTRAPATHS:prepend := "${THISDIR}/gcc-13.2:"

SRC_URI:append = " file://0005-optional-libstdc.patch"
