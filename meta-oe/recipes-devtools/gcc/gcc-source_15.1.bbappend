FILESEXTRAPATHS:prepend := "${THISDIR}/gcc-15.1:"

SRC_URI:append = "file://0005-optional-libstdc.patch"
