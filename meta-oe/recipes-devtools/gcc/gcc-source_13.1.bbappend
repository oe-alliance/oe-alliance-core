FILESEXTRAPATHS:prepend := "${THISDIR}/gcc-13.1:"

SRC_URI:append = " file://0005-optional-libstdc.patch"
