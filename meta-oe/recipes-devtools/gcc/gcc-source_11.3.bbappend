FILESEXTRAPATHS:prepend := "${THISDIR}/gcc-11.2:"

SRC_URI:append = " file://0005-optional-libstdc.patch"
