FILESEXTRAPATHS:prepend := "${THISDIR}/gcc-12.2:"

SRC_URI:append = " file://0005-optional-libstdc.patch"
