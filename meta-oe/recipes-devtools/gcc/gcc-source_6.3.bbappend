FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-6.3:"

SRC_URI += "file://0076-Fix-build-with-gcc-6.patch"
