FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-misc-rename-copy_file_range-to-copy_file_chunk.patch"

