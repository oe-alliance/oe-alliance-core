RDEPENDS_${PN} += "${PYTHON_PN}-cssselect"

include ${PYTHON_PN}-package-split.inc
