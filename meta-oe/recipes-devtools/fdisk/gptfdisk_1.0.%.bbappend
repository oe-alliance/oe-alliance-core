CFLAGS+="-D_FILE_OFFSET_BITS=64"
CXXFLAGS+="-Wall -D_FILE_OFFSET_BITS=64"

