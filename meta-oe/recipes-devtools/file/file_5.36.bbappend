CFLAGS_append_sh4 = " -std=c99"

