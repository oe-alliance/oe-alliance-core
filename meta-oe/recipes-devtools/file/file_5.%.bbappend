CFLAGS:sh4 += "-std=gnu11"
