SRC_URI += "file://fix_mips_build.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/nodejs:"
