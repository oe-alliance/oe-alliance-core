FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://build-with-gcc15.patch"
