EXTRA_OEMAKE:append:mipsel = " LIBS='-latomic -lm -lz -lnuma -laio'"
