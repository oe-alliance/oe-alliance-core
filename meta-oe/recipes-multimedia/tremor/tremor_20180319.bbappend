SRC_URI_remove = "git://git.xiph.org/tremor.git;protocol=https"
SRC_URI_append = "git://gitlab.xiph.org/xiph/tremor.git;protocol=https"

SRCREV = "b56ffce0c0773ec5ca04c466bc00b1bbcaf65aef"
