PACKAGECONFIG:append = " \
    cdio dvdread \
"
PACKAGE_NO_LOCALE = "1"

PV = "1.28.2"
SRC_URI[sha256sum] = "fe39a5ee7115e37de9eb65d899ec84c93e6e26ed3ffe25c6d5176cececbab572"
