PV = "1.28.5"

SRC_URI[sha256sum] = "4f3cf082a2faa095fcd84193bb221ad2fdcce9bc8c7b3f53024901fc25ecb5be"
