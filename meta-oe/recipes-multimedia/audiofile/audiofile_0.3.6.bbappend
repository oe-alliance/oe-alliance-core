DEPENDS += "alsa-lib"