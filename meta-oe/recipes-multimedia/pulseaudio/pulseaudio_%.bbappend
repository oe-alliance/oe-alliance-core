DEPENDS:append:sh4 = " stlirc"
PACKAGE_NO_LOCALE = "1"
