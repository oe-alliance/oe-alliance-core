DEPENDS_append_sh4 = " stlirc"