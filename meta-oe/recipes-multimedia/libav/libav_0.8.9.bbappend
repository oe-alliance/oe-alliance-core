RSUGGESTS_${PN} = ""

PROVIDES =+ " libavcodec53 libavformat53"
PACKAGES =+ " libavcodec53 libavformat53"
