PROVIDES =+ " libtheora0"
