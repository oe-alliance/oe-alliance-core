PACKAGE_NO_LOCALE = "1"

INSANE_SKIP += "32bit-time"
