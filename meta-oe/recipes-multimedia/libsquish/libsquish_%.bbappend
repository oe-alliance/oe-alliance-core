FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-multilib-libdir.patch"