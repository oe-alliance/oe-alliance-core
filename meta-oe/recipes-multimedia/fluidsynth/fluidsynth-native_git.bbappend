SRC_URI = "git://github.com/FluidSynth/fluidsynth.git;branch=master;protocol=https"
SRCREV = "3cf3f447188fabf5431576a6684e94384c0f2a36"
PV = "2.3.1"