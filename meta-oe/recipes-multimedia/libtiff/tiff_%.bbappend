# Disable anything auto depending
EXCLUDE_FROM_SHLIBS = "1"