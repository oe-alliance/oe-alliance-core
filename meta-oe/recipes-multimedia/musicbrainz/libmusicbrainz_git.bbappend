B:pn-libmusicbrainz = "${WORKDIR}/git"