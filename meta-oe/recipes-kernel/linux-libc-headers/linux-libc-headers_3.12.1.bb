require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "f6f34baf553f278ff4637d8eaeff5dcd"
SRC_URI[sha256sum] = "9d5ff597c144e1cbd5b5a9696b99ae7045bf462094baa5dcb935ded7ceae7a64"
