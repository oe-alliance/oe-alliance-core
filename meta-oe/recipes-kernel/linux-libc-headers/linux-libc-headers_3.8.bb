require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "1c738edfc54e7c65faeb90c436104e2f"
SRC_URI[sha256sum] = "e070d1bdfbded5676a4f374721c63565f1c969466c5a3e214004a136b583184b"
