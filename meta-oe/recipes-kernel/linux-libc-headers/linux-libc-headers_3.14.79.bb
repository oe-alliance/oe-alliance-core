require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "ec5b09d8ad2ebf92e6f51a727a338559"
SRC_URI[sha256sum] = "931fae75c70c4a805629f91ba171769b7e0606fd3e89d00be60ed806aa7045c9"
