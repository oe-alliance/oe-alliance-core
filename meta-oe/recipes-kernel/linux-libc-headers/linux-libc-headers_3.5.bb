require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "24153eaaa81dedc9481ada8cd9c3b83d"
SRC_URI[sha256sum] = "b985ce383f0cfd940d988d4c99a84899028327aca8c29b420678241f26fdb342"
