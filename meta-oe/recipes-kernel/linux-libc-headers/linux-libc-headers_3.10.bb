KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "4f25cd5bec5f8d5a7d935b3f2ccb8481"
SRC_URI[sha256sum] = "df27fa92d27a9c410bfe6c4a89f141638500d7eadcca5cce578954efc2ad3544"
