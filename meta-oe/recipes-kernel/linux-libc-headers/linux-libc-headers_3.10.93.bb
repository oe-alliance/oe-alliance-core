KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "173af0895f1d20fd1fd4c2961e05eabb"
SRC_URI[sha256sum] = "bae4a24c1cc7f4f7ea6666de9b714f991ed31c83d7904a497ad03f391627a423"
