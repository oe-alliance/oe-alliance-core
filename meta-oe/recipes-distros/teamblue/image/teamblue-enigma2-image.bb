SUMMARY = "Build teamblue Image without Feed"

require teamblue-image.inc
