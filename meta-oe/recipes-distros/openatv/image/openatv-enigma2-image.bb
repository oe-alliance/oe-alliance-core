SUMMARY = "Build openATV Image without Feed"

require openatv-image.inc
