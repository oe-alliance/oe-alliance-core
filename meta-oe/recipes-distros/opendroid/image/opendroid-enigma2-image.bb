SUMMARY = "Build opendroid Image without Feed"

require opendroid-image.inc
