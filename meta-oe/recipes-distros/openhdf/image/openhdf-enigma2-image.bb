SUMMARY = "Build openHDF Image with Feed"

require openhdf-image.inc
