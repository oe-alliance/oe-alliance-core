SUMMARY = "openhdf meta package for enigma2 picon sets"
SECTION = "base"
LICENSE = "proprietary"
inherit allarch

require conf/license/license-gplv2.inc

ALLOW_EMPTY_${PN} = "1"
PV = "1"
PR = "r5"

DEPENDS = ""
