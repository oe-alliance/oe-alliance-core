SUMMARY = "Build openNFR Image without Feed"

require opennfr-image.inc
