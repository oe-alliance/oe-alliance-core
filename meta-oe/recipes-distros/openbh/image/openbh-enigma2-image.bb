SUMMARY = "Build OpenBh Image without Feed"

require openbh-image.inc
