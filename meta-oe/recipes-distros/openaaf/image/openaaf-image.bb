SUMMARY = "Build openAAF Image with Feed"

DEPENDS += "openaaf-feeds"

require openaaf-image.inc
