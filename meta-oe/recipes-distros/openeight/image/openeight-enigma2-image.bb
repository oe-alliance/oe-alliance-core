SUMMARY = "Build openeight Image without Feed"

require openeight-image.inc
