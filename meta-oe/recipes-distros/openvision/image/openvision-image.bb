SUMMARY = "Build Open Vision Image with Feed"

DEPENDS += "openvision-feeds"

require openvision-image.inc
