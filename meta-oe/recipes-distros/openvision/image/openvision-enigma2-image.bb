SUMMARY = "Build Open Vision Image without Feed"

require openvision-image.inc
