SUMMARY = "Build openspa Image without Feed"

require openspa-image.inc
