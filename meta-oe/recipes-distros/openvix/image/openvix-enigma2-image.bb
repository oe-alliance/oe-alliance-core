SUMMARY = "Build openVIX Image without Feed"

DEPENDS += "enigma2-skins-openvix"

require openvix-image.inc
