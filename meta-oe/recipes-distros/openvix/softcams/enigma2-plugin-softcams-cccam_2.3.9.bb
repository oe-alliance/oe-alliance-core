CAMNAME="CCcam"

require cccam-common.inc
SUMMARY:${PN}:append = " (Sky-DE patched)"
DESCRIPTION:${PN}:append = "\n \
- with patch for support of German Sky V13/V14/V15 cards\n \
- this is a fake version, patched from old 2.0.xx version"
