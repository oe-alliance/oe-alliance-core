CAMNAME="CCcam"

require cccam-common.inc

SUMMARY:${PN}:append = " (Long ECM & Sky-DE patched)"
DESCRIPTION:${PN}:append = "\n \
- with patch for long ECM\n \
- with patch for support of German Sky V13/V14/V15 cards"
