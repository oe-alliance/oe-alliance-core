CAMNAME="mgcamd"

require mgcamd-common.inc
