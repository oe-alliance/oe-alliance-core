CAMNAME="CCcam"

require cccam-common82.inc

SUMMARY:${PN}:append = " (Zgemma 8.2H)"
DESCRIPTION:${PN}:append = "\n \
- zgemma 8.2H"
