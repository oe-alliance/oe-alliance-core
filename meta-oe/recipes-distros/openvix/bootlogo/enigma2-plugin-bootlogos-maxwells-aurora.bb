SUMMARY = "Maxwell aurora bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r2"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_Aurora_r2.zip"

SRC_URI[md5sum] = "48c92e45d25d8e21ca44ead6e6fb63f1"
SRC_URI[sha256sum] = "0949254b912a5cf2d0049fefd3a16e3ee6edcb0dd200b762d019cab7c3cb9dc4"
