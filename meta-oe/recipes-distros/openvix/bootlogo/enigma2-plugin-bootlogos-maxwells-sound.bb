SUMMARY = "Maxwell sound bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r0"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_sound.zip"

SRC_URI[md5sum] = "5a14abfbc38392c701c60cff9ed5f86d"
SRC_URI[sha256sum] = "2388725a6cf91e53ea16927a522422550f4735fdfda18fd1da75681c508958d0"
