SUMMARY = "1080 bootlogo by rossi2000"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r1"

SRC_URI = "http://openvix.co.uk/feeds_extras/bootlogos/rossi2000-youvix-1080.zip"

SRC_URI[md5sum] = "C2751D7C29DDB2D9829D03D8B9B920D3"
SRC_URI[sha256sum] = "BFF90177FF32A4509ED7180A641C2F197F09221D72A8611BACE5B69B286608DA"