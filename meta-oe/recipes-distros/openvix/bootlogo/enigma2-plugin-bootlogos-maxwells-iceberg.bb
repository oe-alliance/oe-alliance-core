SUMMARY = "Maxwell iceberg bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r0"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_Iceberg.zip"

SRC_URI[md5sum] = "a0bcfd55225f5194bc1f6383ae964177"
SRC_URI[sha256sum] = "8fc7711d2ec4b7d57e5afa00aca3457c0fd5f23c1cc534753e1e82a89628e3d7"
