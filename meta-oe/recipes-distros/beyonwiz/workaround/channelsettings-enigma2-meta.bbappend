# Australian DVB-T needs none of this stuff

DEPENDS = "\
 "
