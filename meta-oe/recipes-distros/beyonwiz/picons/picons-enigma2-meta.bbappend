PACKAGE_ARCH = "all"

DEPENDS = " \
    enigma2-plugin-picons-tv-australia \
    "