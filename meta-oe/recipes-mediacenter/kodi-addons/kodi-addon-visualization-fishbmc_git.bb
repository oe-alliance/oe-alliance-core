require kodi-addon-visualization.inc

KODIADDONPLUGIN = "fishbmc"
SRCREV = "ad159c5ad481f1f55ad0851502f0883ca54596c9"
PV = "22.1.2+gitr"
