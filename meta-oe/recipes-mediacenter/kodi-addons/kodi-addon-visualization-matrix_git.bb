require kodi-addon-visualization.inc

KODIADDONPLUGIN = "matrix"
SRCREV = "8320deb099ea462ea5c345eed6a5ba968b537f38"
PV = "22.1.1+gitr"
