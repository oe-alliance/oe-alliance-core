require kodi-addon-visualization.inc

KODIADDONPLUGIN = "pictureit"
SRCREV = "407b20c1ea2ed73599473efed5eab98bfcb2e245"
PV = "22.1.1+gitr"
