require kodi-addon-visualization.inc

KODIADDONPLUGIN = "waveform"
SRCREV = "8e62fef394ef8ad0c511c2b74eac3d55447e1573"
PV = "22.1.1+gitr"
