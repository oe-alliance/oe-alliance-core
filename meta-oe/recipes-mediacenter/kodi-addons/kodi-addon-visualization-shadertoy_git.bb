require kodi-addon-visualization.inc

KODIADDONPLUGIN = "shadertoy"
SRCREV = "034413fa3c8a1488c5f2a0603430439b242aa49f"
PV = "22.1.1+gitr"

DEPENDS += "jsoncpp"
