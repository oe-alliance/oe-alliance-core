DEPENDS += "glib-2.0-native"
