require libretro-mupen64plus-next.inc

LIBRETRO_CORE_FILE = "mupen64plus_next_libretro.so"
