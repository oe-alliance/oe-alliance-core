RPROVIDES_${PN} =+ " libgmp10"
