RPROVIDES:${PN} =+ " libgmp10"
