# explain it
TARGET_CFLAGS += "-Wa,--noexecstack"
