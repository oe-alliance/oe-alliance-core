SRC_URI:remove:sh4 = "\
    file://kernel-headers.patch \
"
