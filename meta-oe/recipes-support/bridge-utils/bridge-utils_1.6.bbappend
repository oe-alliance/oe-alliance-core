SRC_URI_remove_sh4 = "\
    file://kernel-headers.patch \
"
