SRC_URI[md5sum] = "e3fba3780a1d818e2932bb3f1f00153b"
SRC_URI[sha256sum] = "2ef449babcdda0bd8db985999eeabce19125c2cc543c939384021ab475dd71df"