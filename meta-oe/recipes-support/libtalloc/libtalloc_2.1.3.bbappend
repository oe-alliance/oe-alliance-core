DEPENDS += "gdb"

B = "${S}"
