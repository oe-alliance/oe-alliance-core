FILESEXTRAPATHS_append := "${THISDIR}/nspr"
SRC_URI += "file://0001-include-stdint.h-for-SSIZE_MAX-and-SIZE_MAX-definiti.patch"
