TARGET_LDFLAGS:sh4 += "-pthread"
