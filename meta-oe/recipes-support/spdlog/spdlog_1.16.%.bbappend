EXTRA_OECMAKE:remove = "-DSPDLOG_BUILD_SHARED=on"
