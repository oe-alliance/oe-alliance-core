EXTRA_OECMAKE_remove = "-DSPDLOG_BUILD_SHARED=on"
