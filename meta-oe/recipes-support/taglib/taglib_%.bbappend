# kodi now utilizes taglib-config and breaks because of cross-compile badness
BINCONFIG = ""
