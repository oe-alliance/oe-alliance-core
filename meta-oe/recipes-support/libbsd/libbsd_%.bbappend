CFLAGS += "-Wno-implicit-function-declaration"
