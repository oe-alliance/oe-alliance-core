PACKAGE_NO_LOCALE = "1"

RDEPENDS:${PN}:append = " nghttp2"
