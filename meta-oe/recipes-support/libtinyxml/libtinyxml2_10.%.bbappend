CXXFLAGS:mipsel:append = " -fPIC"
