CXXFLAGS_mipsel_append = " -fPIC"
