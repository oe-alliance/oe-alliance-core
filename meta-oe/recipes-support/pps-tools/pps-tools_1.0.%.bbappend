CFLAGS:append:sh4 = " -DN_PPS=18"

