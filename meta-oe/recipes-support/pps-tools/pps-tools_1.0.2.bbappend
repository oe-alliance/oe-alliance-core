CFLAGS_append_sh4 = " -DN_PPS=18"

