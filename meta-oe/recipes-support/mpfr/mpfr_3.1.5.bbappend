RPROVIDES_${PN} =+ " libmpfr4"
