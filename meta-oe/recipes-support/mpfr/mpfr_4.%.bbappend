RPROVIDES:${PN} =+ " libmpfr4"
