PACKAGE_NO_LOCALE = "1"

PACKAGECONFIG:remove:class-native = "seccomp"
PACKAGECONFIG:remove:class-nativesdk = "seccomp"

