FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PR:append = ".4"
