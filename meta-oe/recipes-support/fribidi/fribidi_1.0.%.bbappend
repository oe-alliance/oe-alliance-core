FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Removed-HAVE_CONFIG_H-from-public-API.patch"
