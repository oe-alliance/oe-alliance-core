DEPENDS += "eudev zlib"
