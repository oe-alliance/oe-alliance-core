LDFLAGS:append:mipsarch = " -libatomic"
