RPROVIDES_${PN} += " libusb-0.1-4"
