require libshairport.inc

LIC_FILES_CHKSUM="file://COPYING;md5=d41d8cd98f00b204e9800998ecf8427e"

SRC_URI[archive.md5sum] = "9f5488a66e4b0435254906ab89a7336d"
SRC_URI[archive.sha256sum] = "e830a8e3730490524d327c40d54b4b9bb1bf735d9be102954fac24c569520c43"
