FILESEXTRAPATHS_prepend := "${THISDIR}/icu:"
SRC_URI += "file://icudt58l.zip"
