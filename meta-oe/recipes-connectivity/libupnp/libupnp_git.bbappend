CFLAGS += "-D_LARGE_FILE_SOURCE -D_FILE_OFFSET_BITS=64"
