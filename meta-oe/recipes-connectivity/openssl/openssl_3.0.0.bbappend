inherit upx-compress

PACKAGE_ARCH = "${MACHINE_ARCH}"
