require transmission.inc

SRC_URI[archive.md5sum] = "03927018656c4b54a92156ab59a8de74"
SRC_URI[archive.sha256sum] = "af1ec1b7c49def45be1124f67d0d36e1c8cfdaccd5ed0d6799debeb47ffbf55e"
