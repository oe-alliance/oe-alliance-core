DEPENDS:append = " virtual/crypt"
