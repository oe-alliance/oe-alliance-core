EXTRA_OECONF_append = " --localstatedir=${root_prefix}"
