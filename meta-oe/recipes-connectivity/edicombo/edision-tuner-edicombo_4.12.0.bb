require edision-tuner-edicombo.inc

COMPATIBLE_MACHINE = "^(xc7346|xc7362)$"

KV = "4.12.0"

SRCDATE = "20170526"

SRC_URI[driver.md5sum] = "b2a4d6812571c2641c91fab4e6b46f8e"
SRC_URI[driver.sha256sum] = "c98410d32164643219b83274ca1b585f4cc1e57576c7b900ab2af70bf939ccb8"
