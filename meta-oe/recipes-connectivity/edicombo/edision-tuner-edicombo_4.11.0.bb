require edision-tuner-edicombo.inc

COMPATIBLE_MACHINE = "^(xc7346|xc7362)$"

KV = "4.11.0"

SRCDATE = "20170526"

SRC_URI[driver.md5sum] = "45f38a153b081f83af4afb7d61a2248f"
SRC_URI[driver.sha256sum] = "f679f5d2d5ec817952f0a8324d3c385899cae11482ca5a07c07d1f6779b8fc4f"
