require edision-tuner-edicombo.inc

COMPATIBLE_MACHINE = "dags7335"

KV = "3.9.7-R1"

SRCDATE = "20170526"

SRC_URI[driver.md5sum] = "c7d1ca169776acd2f18fe31d80849ce8"
SRC_URI[driver.sha256sum] = "e312dcf149c09a18397aef822ed07d7506a007fb20483328d7929fd99a675939"
