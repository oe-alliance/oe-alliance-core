require edision-tuner-edicombo.inc

COMPATIBLE_MACHINE = "dags7356"

KV = "3.9.7-R2"

SRCDATE = "20170526"

SRC_URI[driver.md5sum] = "8336f5c6566bdd4dbda8c767c5f5a88a"
SRC_URI[driver.sha256sum] = "f9c8669e87614a77c5e816daee76e6718f9baa91b4e619004315a223a48105da"
