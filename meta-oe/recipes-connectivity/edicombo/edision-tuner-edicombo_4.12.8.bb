require edision-tuner-edicombo.inc

COMPATIBLE_MACHINE = "^(xc7346|xc7362)$"

KV = "4.12.8"

SRCDATE = "20170526"

SRC_URI[driver.md5sum] = "10cbca8685af736e59ed1e75b4e17508"
SRC_URI[driver.sha256sum] = "7c2b2917a0c4d41003b64ef6c601623a830f6571c907a569003b6c5df4baf8bb"
