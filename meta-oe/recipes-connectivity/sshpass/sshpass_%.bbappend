# vuplus-opera-browser-util needs sshpass-native, upstream builds target only.
BBCLASSEXTEND += "native"
