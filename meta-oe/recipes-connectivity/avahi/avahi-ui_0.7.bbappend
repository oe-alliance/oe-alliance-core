ANY_OF_DISTRO_FEATURES += "${GTK2DISTROFEATURES}"

AVAHI_GTK = "gtk"
