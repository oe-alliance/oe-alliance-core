inherit upx_compress