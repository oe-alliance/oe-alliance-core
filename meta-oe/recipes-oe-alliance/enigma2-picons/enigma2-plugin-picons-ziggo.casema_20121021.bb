PICON_SATNAMES = "ziggo.casema"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-casema-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "d9511adb46393a8c582b3e576389a6d8"
SRC_URI[sha256sum] = "46cdd9634dedec2cc3546da16fc1359589f31ef78182193fa2189b5c31ac02d2"
