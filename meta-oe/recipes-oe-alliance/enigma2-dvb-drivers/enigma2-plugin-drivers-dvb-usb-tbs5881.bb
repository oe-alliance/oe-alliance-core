SUMMARY = "USB DVB driver package for the TBS5881 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5881"

require tbs-usb-driver.inc
