SUMMARY = "USB DVB driver package for the TBS5927 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5927"

require tbs-usb-driver.inc
