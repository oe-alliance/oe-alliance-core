SUMMARY = "USB DVB driver package for the TBS5930 Lite tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5930-lite"

require tbs-usb-driver.inc
