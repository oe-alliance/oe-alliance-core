SUMMARY = "USB DVB driver package for the TBS5990 dual tuner"

TBS_USB_BRIDGE = "tbs-cx231xx-stack"

require tbs-usb-driver.inc
