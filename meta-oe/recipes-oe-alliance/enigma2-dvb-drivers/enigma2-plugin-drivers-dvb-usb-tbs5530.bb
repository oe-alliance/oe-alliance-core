SUMMARY = "USB DVB driver package for the TBS5530 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5530"

require tbs-usb-driver.inc
