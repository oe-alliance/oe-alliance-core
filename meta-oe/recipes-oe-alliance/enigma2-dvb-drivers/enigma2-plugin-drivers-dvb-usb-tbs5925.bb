SUMMARY = "USB DVB driver package for the TBS5925 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5925"

require tbs-usb-driver.inc
