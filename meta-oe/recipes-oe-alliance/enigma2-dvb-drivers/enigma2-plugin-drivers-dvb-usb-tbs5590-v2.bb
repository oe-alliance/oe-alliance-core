SUMMARY = "USB DVB driver package for the TBS5590 V2 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5590-v2"

require tbs-usb-driver.inc
