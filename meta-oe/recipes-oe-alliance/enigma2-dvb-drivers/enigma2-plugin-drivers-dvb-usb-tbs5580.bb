SUMMARY = "USB DVB driver package for the TBS5580 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5580"

require tbs-usb-driver.inc
