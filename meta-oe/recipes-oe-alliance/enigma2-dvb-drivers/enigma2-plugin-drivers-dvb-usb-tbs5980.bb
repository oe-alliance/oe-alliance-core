SUMMARY = "USB DVB driver package for the TBS5980 tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5980"

require tbs-usb-driver.inc
