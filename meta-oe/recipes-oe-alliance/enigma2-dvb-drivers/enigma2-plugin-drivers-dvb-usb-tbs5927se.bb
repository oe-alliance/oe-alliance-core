SUMMARY = "USB DVB driver package for the TBS5927SE tuner"

TBS_USB_BRIDGE = "tbs-usb-bridge-5927se"

require tbs-usb-driver.inc
