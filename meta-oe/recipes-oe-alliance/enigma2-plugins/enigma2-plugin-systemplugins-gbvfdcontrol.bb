DESCRIPTION = "vfd controller"
require conf/license/license-gplv2.inc
require conf/python/python3-compileall.inc
PACKAGE_ARCH = "${MACHINE_ARCH}"

PN = "enigma2-plugin-systemplugins-vfdcontrol"

COMPATIBLE_MACHINE = "^(gb800solo|gb7325|gb7252|gb72604|gbmv200|gb7356|gb7358|gb7362|gb73625)$"

inherit gittag

S = "${UNPACKDIR}/${BP}/src"

SRCREV = "${AUTOREV}"
PV = "git"
PKGV = "V${GITPKGVTAG}"

inherit setuptools3-openplugins

SRC_URI = "git://github.com/oe-alliance-plugins/GigaBlueVFDControl.git;protocol=https;branch=main"
