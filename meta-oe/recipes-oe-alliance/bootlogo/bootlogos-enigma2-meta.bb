SUMMARY = "meta file for bootlogos"

require conf/license/license-gplv2.inc
inherit packagegroup

DEPENDS = "\
    "

PR = "r0"
