SUMMARY = "Morph883 0.8W-13E E2 Settings File"

SETTINGS_FILENAME = "morph883_0.8w-13e"

include morph883.inc
