SUMMARY = "ciefp enigma2 settings 19E 16E 13E"

SETTINGS_FILENAME = "ciefp-E2-3sat-19E-16E-13E"

include ciefp.inc
