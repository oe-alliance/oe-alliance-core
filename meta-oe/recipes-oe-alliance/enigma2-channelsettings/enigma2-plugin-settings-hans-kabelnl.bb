SUMMARY = "Hans Kabel NL"

SETTINGS_FILENAME = "e2_hanssettings_kabelNL"

include hans.inc
