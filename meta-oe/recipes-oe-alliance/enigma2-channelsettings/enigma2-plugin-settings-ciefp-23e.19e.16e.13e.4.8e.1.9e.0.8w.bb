SUMMARY = "ciefp enigma2 settings 23E 19E 16E 13E 4.8E 1.9E 0.8W"

SETTINGS_FILENAME = "ciefp-E2-7sat-23E-19E-16E-13E-4.8E-1.9E-0.8W"

include ciefp.inc
