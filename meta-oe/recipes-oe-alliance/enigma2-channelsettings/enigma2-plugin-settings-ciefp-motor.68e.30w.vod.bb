SUMMARY = "ciefp enigma2 settings Motor 68E to 30W and VOD"

SETTINGS_FILENAME = "ciefp-E2-motor-68E-30W-VOD"

include ciefp.inc
