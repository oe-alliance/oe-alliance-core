SUMMARY = "Morph883 13E-19.2E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e-19.2e"

include morph883.inc
