SUMMARY = "Vhannibal E2 Settings File Trial 13e, 19e & 30w"

SETTINGS_FILENAME = "vhannibal.trial.13e.19e.30w"

include oe-alliance-settings.inc
