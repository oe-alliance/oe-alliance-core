SUMMARY = "ciefp enigma2 settings 19E 16E 13E 1.9E 0.8W"

SETTINGS_FILENAME = "ciefp-E2-5sat-19E-16E-13E-1.9E-0.8W"

include ciefp.inc
