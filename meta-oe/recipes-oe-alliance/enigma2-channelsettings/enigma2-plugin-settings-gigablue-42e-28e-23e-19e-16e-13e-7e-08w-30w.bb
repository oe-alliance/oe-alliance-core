DESCRIPTION = "gigablue_42e_28e_23e_19e_16e_13e_7e_08w_30w"

SETTINGS_FILENAME = "gigablue_42e_28e_23e_19e_16e_13e_7e_08w_30w"

include gigablue.inc
