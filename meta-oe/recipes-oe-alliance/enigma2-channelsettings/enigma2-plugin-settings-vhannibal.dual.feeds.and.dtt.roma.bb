SUMMARY = "Vhannibal Dual Feeds E2 Settings File"

SETTINGS_FILENAME = "vhannibal.dual.feeds.and.dtt.roma"

include oe-alliance-settings.inc
