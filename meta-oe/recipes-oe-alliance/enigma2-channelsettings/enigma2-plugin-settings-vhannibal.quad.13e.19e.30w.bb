SUMMARY = "Vhannibal E2 Settings File For 13e,19e & 30w"

SETTINGS_FILENAME = "vhannibal.quad.13e.19e.30e"

include oe-alliance-settings.inc
