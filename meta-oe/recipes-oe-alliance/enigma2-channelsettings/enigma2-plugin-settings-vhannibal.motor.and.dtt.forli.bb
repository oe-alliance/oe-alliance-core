SUMMARY = "Vhannibal Motor E2 Settings File"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.forli"

include oe-alliance-settings.inc
