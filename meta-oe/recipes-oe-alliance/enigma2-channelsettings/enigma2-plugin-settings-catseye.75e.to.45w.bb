SUMMARY = "Catseye E2 Settings File For 75E - 60W"

SETTINGS_FILENAME = "catseye.75e.to.60w"

include oe-alliance-settings.inc
