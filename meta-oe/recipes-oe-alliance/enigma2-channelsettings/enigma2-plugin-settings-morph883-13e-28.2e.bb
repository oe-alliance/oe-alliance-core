SUMMARY = "Morph883 13E-28.2E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e-28.2e"

include morph883.inc
