SUMMARY = "Morph883 30W-13E-19.2E E2 Settings File"

SETTINGS_FILENAME = "morph883_30w-13e-19.2e"

include morph883.inc
