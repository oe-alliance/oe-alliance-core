SUMMARY = "Morph883 13E-16E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e-16e"

include morph883.inc
