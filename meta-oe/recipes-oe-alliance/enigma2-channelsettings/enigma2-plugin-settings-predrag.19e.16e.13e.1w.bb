SUMMARY = "Predr@d 19E, 16E, 13E, 1W"

SETTINGS_FILENAME = "predrag.19e.16e.13e.1w"

include oe-alliance-settings.inc
