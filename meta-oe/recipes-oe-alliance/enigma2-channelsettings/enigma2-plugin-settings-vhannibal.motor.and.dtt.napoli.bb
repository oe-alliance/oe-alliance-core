SUMMARY = "Vhannibal Motor E2 Settings File"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.napoli"

include oe-alliance-settings.inc
