SUMMARY = "Morph883 13E-42E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e-42e"

include morph883.inc
