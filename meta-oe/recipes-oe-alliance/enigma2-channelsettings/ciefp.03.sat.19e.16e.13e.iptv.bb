SUMMARY = "Ciefp E2 Settings File"

SETTINGS_FILENAME = "ciefp.03.sat.19e.16e.13e.iptv.db"

include oe-alliance-settings.inc