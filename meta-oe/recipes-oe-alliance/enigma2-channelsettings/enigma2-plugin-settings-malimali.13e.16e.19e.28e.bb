SUMMARY = "Malimali 13E, 16E, 19.2E, 28.2E Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.13e.16e.19e.28e"

include oe-alliance-settings.inc
