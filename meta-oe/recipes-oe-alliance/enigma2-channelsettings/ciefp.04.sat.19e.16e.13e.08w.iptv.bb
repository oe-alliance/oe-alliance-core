SUMMARY = "Ciefp E2 Settings File"

SETTINGS_FILENAME = "ciefp.04.sat.19e.16e.13e.08w.iptv.db"

include oe-alliance-settings.inc