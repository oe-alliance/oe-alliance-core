SUMMARY = "Predr@d 28.2E ,19.2E ,16E, 13E, 0.8W"

SETTINGS_FILENAME = "predrag.28e.19e.16e.13e.0.8w"

include oe-alliance-settings.inc
