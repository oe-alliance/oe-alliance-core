SATNAMES = "13e19e23e28e"

require rytec-settings.inc

S = "${WORKDIR}/Rytec_E2_${SATNAMES}_${RYTECSETTINGS_SRCDATE}"

SRC_URI[md5sum] = "92a222faccd02c1b68f083dd75623a56"
SRC_URI[sha256sum] = "f3fe05af800feb01d63840a11f1bb778e16ca30e9ee0035a3c3427071fe3bd3c"
