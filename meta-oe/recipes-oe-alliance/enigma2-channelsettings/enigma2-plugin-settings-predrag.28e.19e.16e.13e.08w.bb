SUMMARY = "Predr@d 28E, 19E, 16E, 13E, 08W"

SETTINGS_FILENAME = "predrag.28e.19e.16e.13e.08w"

include oe-alliance-settings.inc
