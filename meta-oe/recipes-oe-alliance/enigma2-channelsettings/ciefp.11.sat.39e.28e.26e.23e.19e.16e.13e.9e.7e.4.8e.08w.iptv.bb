SUMMARY = "Ciefp E2 Settings File"

SETTINGS_FILENAME = "ciefp.11.sat.39e.28e.26e.23e.19e.16e.13e.9e.7e.4.8e.08w.iptv.db"

include oe-alliance-settings.inc