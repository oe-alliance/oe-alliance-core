SUMMARY = "Morph883 9E-13E-19.2E E2 Settings File"

SETTINGS_FILENAME = "morph883_9e-13e-19.2e"

include morph883.inc
