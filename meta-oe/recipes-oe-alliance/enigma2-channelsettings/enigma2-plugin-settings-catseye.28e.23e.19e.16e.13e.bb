SUMMARY = "Catseye E2 Settings File For 28.2E-23.5E-19.2E-16E-13E"

SETTINGS_FILENAME = "catseye.28e.23e.19e.16e.13e"

include oe-alliance-settings.inc
