SUMMARY = "Ciefp E2 Settings File"

SETTINGS_FILENAME = "ciefp.motor.68e.30w.iptv.db"

include oe-alliance-settings.inc