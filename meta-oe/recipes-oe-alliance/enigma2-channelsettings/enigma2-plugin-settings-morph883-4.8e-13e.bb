SUMMARY = "Morph883 4.8E 13E E2 Settings File"

SETTINGS_FILENAME = "morph883_4.8e-13e"

include morph883.inc