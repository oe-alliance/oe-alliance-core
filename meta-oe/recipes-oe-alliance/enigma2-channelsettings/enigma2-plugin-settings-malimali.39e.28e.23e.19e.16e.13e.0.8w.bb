SUMMARY = "Malimali 39E, 28.2E, 23.5E, 19.2E, 16E, 13E, 0.8W Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.39e.28e.23e.19e.16e.13e.0.8w"

include oe-alliance-settings.inc
