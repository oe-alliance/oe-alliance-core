SUMMARY = "Morph883 30W-13E E2 Settings File"

SETTINGS_FILENAME = "morph883_30w-13e"

include morph883.inc
