SUMMARY = "Morph883 13E-19.2E-42E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e-19.2e-42e"

include morph883.inc
