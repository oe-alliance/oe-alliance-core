SUMMARY = "Morph883 Motor E2 Settings File"

SETTINGS_FILENAME = "morph883_motor"

include morph883.inc
