SUMMARY = "Morph883 13E-23.5E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e-23.5e"

include morph883.inc
