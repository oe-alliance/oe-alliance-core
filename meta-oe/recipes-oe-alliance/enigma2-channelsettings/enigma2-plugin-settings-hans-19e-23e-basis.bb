SUMMARY = "Hans 19E,23E Basis"

SETTINGS_FILENAME = "e2_hanssettings_19e_23e_basis"

include hans.inc
