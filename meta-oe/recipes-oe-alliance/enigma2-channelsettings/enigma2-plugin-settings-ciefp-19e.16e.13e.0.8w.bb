SUMMARY = "ciefp enigma2 settings 19E 16E 13E 0.8W"

SETTINGS_FILENAME = "ciefp-E2-4sat-19E-16E-13E-0.8W"

include ciefp.inc
