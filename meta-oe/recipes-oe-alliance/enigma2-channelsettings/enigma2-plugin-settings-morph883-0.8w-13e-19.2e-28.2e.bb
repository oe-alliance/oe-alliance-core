SUMMARY = "Morph883 0.8W-13E-19.2E-28.2E E2 Settings File"

SETTINGS_FILENAME = "morph883_0.8w-13e-19.2e-28.2e"

include morph883.inc
