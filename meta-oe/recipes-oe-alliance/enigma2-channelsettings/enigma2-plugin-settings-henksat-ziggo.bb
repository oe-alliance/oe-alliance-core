SUMMARY = "Henksat Ziggo"

SETTINGS_FILENAME = "e2_henksat_ziggo"

include henksat.inc
