SUMMARY = "Morph883 13E E2 Settings File"

SETTINGS_FILENAME = "morph883_13e"

include morph883.inc
