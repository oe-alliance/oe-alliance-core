SUMMARY = "Morph883 4.8E-13E-19.2E E2 Settings File"

SETTINGS_FILENAME = "morph883_4.8e-13e-19.2e"

include morph883.inc
