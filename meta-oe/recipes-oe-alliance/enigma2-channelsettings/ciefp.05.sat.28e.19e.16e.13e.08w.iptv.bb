SUMMARY = "Ciefp E2 Settings File"

SETTINGS_FILENAME = "ciefp.05.sat.28e.19e.16e.13e.08w.iptv.db"

include oe-alliance-settings.inc