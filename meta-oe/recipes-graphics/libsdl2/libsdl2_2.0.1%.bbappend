FILESEXTRAPATHS:append := "${THISDIR}/files"

SRC_URI += "file://add-missing-keys.patch"
