FILESEXTRAPATHS:append := "${THISDIR}/files"

SRC_URI += "file://fix-cairo-version.patch"
