CFLAGS_append_sh4 = " -std=gnu11"
