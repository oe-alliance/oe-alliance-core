FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PR .= ".1"