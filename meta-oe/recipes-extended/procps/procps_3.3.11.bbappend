FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PR .= ".1"