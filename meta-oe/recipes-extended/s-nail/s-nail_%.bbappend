CFLAGS:append = " -fPIC"
LDFLAGS:append = " -shared"
