inherit upx-compress
