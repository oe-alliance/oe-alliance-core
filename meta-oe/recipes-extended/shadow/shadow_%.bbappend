inherit upx-compress

PACKAGE_NO_LOCALE = "1"
