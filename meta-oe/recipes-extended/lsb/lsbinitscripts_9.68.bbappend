ALTERNATIVE_PRIORITY = "10"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
