# this is causing unpack failures
SRC_URI_remove = "file://CVE-2019-13232.patch"
