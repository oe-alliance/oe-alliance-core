FINAL_LIBS_mipsel = "-latomic"
