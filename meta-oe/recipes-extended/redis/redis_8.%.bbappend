FINAL_LIBS:mipsel = "-latomic"
EXTRA_OEMAKE:append:task-install = " PREFIX=${D}${prefix}"
