DEPENDS = "libxau libxcb libsm"

SSTATE_ALLOW_OVERLAP_FILES += "${STAGING_INCDIR}/gif_lib.h"
