FILESEXTRAPATHS_append := ":${THISDIR}/ghostscript"
