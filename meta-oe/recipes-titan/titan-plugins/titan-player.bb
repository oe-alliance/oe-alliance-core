SUMMARY = "meta file for Titan Player Plugins"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
    titan-plugin-player-foldericons \
    titan-plugin-player-codecpack \
"

PR = "r0"
