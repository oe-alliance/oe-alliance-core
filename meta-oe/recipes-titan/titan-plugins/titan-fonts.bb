SUMMARY = "meta file for Titan Fonts"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
  titan-plugin-fonts-actionmanitalic \
  titan-plugin-fonts-alpharomanieg98 \
  titan-plugin-fonts-croissant \
  titan-plugin-fonts-defaultfont \
  titan-plugin-fonts-digifaceregular \
  titan-plugin-fonts-goodtime \
  titan-plugin-fonts-ihatecomicsans \
  titan-plugin-fonts-lydianbolditalicbt \
  titan-plugin-fonts-mightyzeocaps \
  titan-plugin-fonts-monoglyceridedemibold \
  titan-plugin-fonts-newgothicbt \
  titan-plugin-fonts-paddingtonbold \
  titan-plugin-fonts-ploverbold \
"

PR = "r0"
