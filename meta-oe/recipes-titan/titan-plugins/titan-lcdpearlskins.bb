SUMMARY = "meta file for Titan LCD Pearl Skins"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
  titan-plugin-lcdpearlskins-atemio.style \
  titan-plugin-lcdpearlskins-blau.mit.picon \
  titan-plugin-lcdpearlskins-mrp.style \
  titan-plugin-lcdpearlskins-only.picon \
  titan-plugin-lcdpearlskins-picon.gross.schwarz \
  titan-plugin-lcdpearlskins-schwarz.ohne.picon \
"

PR = "r0"
