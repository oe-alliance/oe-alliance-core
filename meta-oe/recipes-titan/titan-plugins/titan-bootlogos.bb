SUMMARY = "meta file for Titan Bootlogos"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
  titan-plugin-bootlogos-atemio \
  titan-plugin-bootlogos-bikergirl \
  titan-plugin-bootlogos-blueskull \
  titan-plugin-bootlogos-cityflash \
  titan-plugin-bootlogos-enigmalinux \
  titan-plugin-bootlogos-fantasygirl \
  titan-plugin-bootlogos-fantasygirl2 \
  titan-plugin-bootlogos-firelady \
  titan-plugin-bootlogos-fireskull \
  titan-plugin-bootlogos-footballgirls \
  titan-plugin-bootlogos-ghostrider \
  titan-plugin-bootlogos-giantgirl \
  titan-plugin-bootlogos-iceage2scrapufs910 \
  titan-plugin-bootlogos-linuxgirl \
  titan-plugin-bootlogos-planets \
  titan-plugin-bootlogos-thegrimreaper \
  titan-plugin-bootlogos-titan1 \
  titan-plugin-bootlogos-titan2 \
  titan-plugin-bootlogos-titan3 \
  titan-plugin-bootlogos-titan5 \
  titan-plugin-bootlogos-titannit1 \
  titan-plugin-bootlogos-titannit2 \
  titan-plugin-bootlogos-titannit3 \
  titan-plugin-bootlogos-titannit4 \
  titan-plugin-bootlogos-titannit5 \
  titan-plugin-bootlogos-titannit6 \
  titan-plugin-bootlogos-titannit7 \
  titan-plugin-bootlogos-zombie \
"

PR = "r0"
