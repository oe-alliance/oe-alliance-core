SRCDATE = "20150403"
SRCDATE_PR = "r0"

require titan-libgles.inc

SRC_URI[md5sum] = "c0afed5e2179709dd63277ea359d536c"
SRC_URI[sha256sum] = "88fa584db85b8fb4e15e869acfd10fc2928f14df739d6abadb484662b17388d3"
