# Locale data is shipped by minilocale as a pre-baked tarball.
ENABLE_BINARY_LOCALE_GENERATION = "0"
GLIBC_GENERATE_LOCALES = ""
