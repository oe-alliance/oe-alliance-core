SRC_URI += " file://0001-fix-build-for-old-libcheader.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"