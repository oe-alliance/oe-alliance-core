BINARY_LOCALE_ARCHES += "sh sh4"
