FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://add_missing_IOfwide.patch"

