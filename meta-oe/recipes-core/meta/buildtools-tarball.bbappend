TARGET_ARCH_dreamboxv1 = "mipsel"
TARGET_OS_dreamboxv1 = "linux"
