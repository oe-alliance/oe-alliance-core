TARGET_ARCH:dreamboxv1 = "mipsel"
TARGET_OS:dreamboxv1 = "linux"