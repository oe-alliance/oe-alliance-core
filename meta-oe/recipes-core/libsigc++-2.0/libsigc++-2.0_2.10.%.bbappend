CXXFLAGS_append_sh4 += " -std=c++11 -fPIC -fno-strict-aliasing "
CXXFLAGS_append_cube = " -std=gnu++11 "
