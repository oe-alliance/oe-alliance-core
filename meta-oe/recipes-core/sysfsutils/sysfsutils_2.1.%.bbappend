PROVIDES =+ " libsysfs2"
PACKAGES =+ " libsysfs2"

BBCLASSEXTEND = "native"
