inherit upx

