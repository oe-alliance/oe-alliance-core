FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-libntfs-3g-Makefile.am-fix-install-failed-while-host.patch"

