# package is machine specific
PACKAGE_ARCH := "${MACHINE_ARCH}"
