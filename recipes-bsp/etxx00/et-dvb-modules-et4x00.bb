KV = "3.8.7"
SRCDATE = "20130522"

require et-dvb-modules.inc

SRC_URI[md5sum] = "bc0555fe37722895adb9520aaa0f1106"
SRC_URI[sha256sum] = "9465a536167aa6e37d52ca1d148f64d80bf5c2d66c33c5b36e8e75292350042f"
