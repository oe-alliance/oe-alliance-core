KV = "3.6.0"
SRCDATE = "20121017"

require et-dvb-modules.inc

SRC_URI[md5sum] = "7800d54ad9d930501baec006f94f2fd8"
SRC_URI[sha256sum] = "9081bca43d7e68b6be4e9ec3b3b1576d3f2ceffbb04f92e748727be46b6d1930"
