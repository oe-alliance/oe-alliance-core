SRC_URI[md5sum] = "19abe3fcaf21ff22ea2e78a4fe6c3026"
SRC_URI[sha256sum] = "20339a4cf77237b515b667afb59aea1fccf1d768ef9f0daf6c8901361a3d5bb6"
