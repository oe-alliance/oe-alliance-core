KV = "3.13.1"
SRCDATE = "20140227"

require et-dvb-modules.inc

SRC_URI[md5sum] = "eaf68d01581f3dbfb4050381ba911bf7"
SRC_URI[sha256sum] = "89ede6821173480fc5ec7a03d29a20695141a5b01764f9ef283579133cd831a1"
