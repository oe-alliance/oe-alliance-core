KV = "3.6.0"
SRCDATE = "20121017"

require et-dvb-modules.inc

SRC_URI[md5sum] = "622d5034e8650db2751b469826f7b3c1"
SRC_URI[sha256sum] = "051a93ce27a3a573114982180b84ecfca2d5129808b94dbe873da2790e58031b"
