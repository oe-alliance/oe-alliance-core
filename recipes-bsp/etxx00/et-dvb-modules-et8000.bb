KV = "3.13.1"
SRCDATE = "20140131"

require et-dvb-modules.inc

SRC_URI[md5sum] = "3b5767d8722e1038f50eacd3e56f430f"
SRC_URI[sha256sum] = "f9b2c0e7153496d626d81212848addd4a9bb9e5c6d6614f0e08b01929c565b27"
