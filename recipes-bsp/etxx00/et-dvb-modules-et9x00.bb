KV = "3.6.0"
SRCDATE = "20121215"

require et-dvb-modules.inc

SRC_URI[md5sum] = "a937fda2ec13bbbe5e9e3dd9c32bd998"
SRC_URI[sha256sum] = "a7111024161bf73876fc00bf5962c579244cb41fc3da67ebfaeff1634d606262"
