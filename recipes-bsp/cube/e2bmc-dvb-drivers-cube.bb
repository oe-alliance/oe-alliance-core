KV = "2.6.34"
SRCDATE = "20131017"

require e2bmc-dvb-modules.inc

SRC_URI[md5sum] = "b83e743b17b462c06fef13acf95f3375"
SRC_URI[sha256sum] = "7ee03abcc59defe83d4d846a2b7a4cc28f9dab639def4dc87cf862e17fcc58ef"
