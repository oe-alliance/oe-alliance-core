KV = "2.6.34"
SRCDATE = "20140201"

require e2bmc-dvb-modules.inc

SRC_URI[md5sum] = "d594e6a2a8d0ebe6531fad6cd5c33f99"
SRC_URI[sha256sum] = "b69385d11f4cbe27394f8eb3d9bfb5d6e131752a97bf7217c191ee4663e26848"
