KV = "3.2.2"
SRCDATE = "20120917"

SRC_URI[md5sum] = "44fefa28a16b96c69fbcd8d8be3d7f91"
SRC_URI[sha256sum] = "aaa63daf21b260bd5f74542d39a390f89094e421983ca184c3781835b978502c"

SRC_URI = "http://code-ini.com/software/drivers/ini-x000-drivers-${KV}-${SRCDATE}.zip"

require venton-dvb-modules.inc