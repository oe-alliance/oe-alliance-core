KV = "3.6.0"
SRCDATE = "20130118"

SRC_URI[md5sum] = "212f6568b9dcfea87d45c387ee0077a9"
SRC_URI[sha256sum] = "051ca9cb7d822e6bcfd1e164597d222d7d299204599aeb0b46e88e5880912f59"

SRC_URI = "http://code-ini.com/software/drivers/ini-x000-drivers-${KV}-${SRCDATE}.zip"

require venton-dvb-modules.inc
