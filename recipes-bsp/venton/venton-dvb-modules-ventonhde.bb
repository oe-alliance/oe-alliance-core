KV = "3.6.0"
SRCDATE = "20130423"

SRC_URI[md5sum] = "9c8d91154018e56fbb7d57e55c423b3d"
SRC_URI[sha256sum] = "e0965dae0ec3ba9f34e7ecb69f6bcb430a1b72a60f7c705084826327fd0c8096"

SRC_URI = "http://code-ini.com/software/drivers/ini-1000-drivers-${KV}-${SRCDATE}.zip"

require venton-dvb-modules.inc

