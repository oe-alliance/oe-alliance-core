KV = "2.6.37-2.8"
SRCDATE = "20120927"

SRC_URI[md5sum] = "d34812a43cfb262cbbd1c63b5934d5b4"
SRC_URI[sha256sum] = "eb48a69cfc47eed42e69e4c53d68f0003b536dce92d62f11de1274f9703807b4"

SRC_URI = "http://code-ini.com/software/drivers/ini-1000-drivers-${KV}-${SRCDATE}.zip"

require venton-dvb-modules.inc
