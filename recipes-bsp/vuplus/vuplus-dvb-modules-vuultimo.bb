SRCDATE = "20140310"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "32a4ea8533ce21716b2f87b65b42aa8f"
SRC_URI[sha256sum] = "2098d7f626778142eaaa4b24821770c81627e17e06141602a067d5b19b5c7a20"
