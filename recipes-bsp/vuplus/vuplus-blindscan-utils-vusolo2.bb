require vuplus-blindscan-utils.inc

SRC_URI[md5sum] = "71837506e03837679c703187ed4c87dd"
SRC_URI[sha256sum] = "b589a1280f568e7c0f0d1c9a33bb2ba4e5c4a7dbed4d77c5894c75e14274c714"
