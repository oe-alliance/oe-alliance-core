SRCDATE = "20130731"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "93f00e038aa8b62c45c99c82d0bee16e"
SRC_URI[sha256sum] = "9dbcc9a1bf1900fd6bc8663a08021497d887d682d17454763ce65dfbdc1c96e6"
