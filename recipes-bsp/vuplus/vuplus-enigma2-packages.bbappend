PRINC = "1"
ALLOW_EMPTY_${PN} = "1"

PACKAGES = ""

PROVIDES=""

