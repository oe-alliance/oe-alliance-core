SRCDATE = "20140310"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "011a7ebff857ddff7143534fcd650c8a"
SRC_URI[sha256sum] = "a7ed6968878670f168655f2a462eea89221f09139727b2e4c80a99617f5f2061"
