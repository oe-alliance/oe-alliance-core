SRCDATE = "20131108"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "a1d3764fe5e0847f30b72f1ccce5eb25"
SRC_URI[sha256sum] = "941c38f87413f2b9c8d3091402125423d1fc53ff643cdeb571762eed850114b1"
