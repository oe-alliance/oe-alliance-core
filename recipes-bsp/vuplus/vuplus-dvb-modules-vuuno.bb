SRCDATE = "20140310"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "e62a7f3a277823a91e42f1afce47f733"
SRC_URI[sha256sum] = "9b2a3d92c09328689a2779f848899720baeef172c4bbbd936ce0d1c0ab4eee0f"
