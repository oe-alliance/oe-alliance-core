SRCDATE = "20130830"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "bm750"

SRC_URI[md5sum] = "b9cd21c29bd292a58f3842196abcb35e"
SRC_URI[sha256sum] = "b37ae4b98c8791c6fdb8cf00753d589b8b9586e2248660a1bef7bffba1406675"
