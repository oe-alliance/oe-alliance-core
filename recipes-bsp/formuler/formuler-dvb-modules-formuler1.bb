KV = "3.14.2"
SRCDATE = "20140508"

require formuler-dvb-modules.inc
SRC_URI[md5sum] = "e6a2c55ccd01502da9cfcd4367bd614a"
SRC_URI[sha256sum] = "68acf4abd732a4826d30346e8e30dc4ee582334d6edfff1edf5d2aabab77ca32"
