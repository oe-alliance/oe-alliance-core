KV = "3.14.2"
SRCDATE = "20140509"

require skylake-dvb-modules.inc
SRC_URI[md5sum] = "7216d2bf725e02cf0269ecdbc479324a"
SRC_URI[sha256sum] = "683a0b17c4808d437b5f438316cb27e67c17c5fcb5bcc33a63c667031c1ab7dc"
