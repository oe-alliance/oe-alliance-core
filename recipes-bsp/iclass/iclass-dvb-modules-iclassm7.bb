KV = "3.6.0"
SRCDATE = "20121113"

require iclass-dvb-modules.inc

SRC_URI[md5sum] = "af4b4e41df2ce6fa9a151e70c86221a3"
SRC_URI[sha256sum] = "cb9786607dd99351364f86d3b177f0ab1362179d5bc0678fc4cb6189bfb7bad6"
