DOWNLOADMACHINE = "gb800se"

require gigablue-blindscan-utils.inc

SRC_URI[md5sum] = "50685f08d7034e7367ed6db9d9aa186f"
SRC_URI[sha256sum] = "4375b45bacaedb603b4b1fda45d7db41462b305da57feacb391288663ba84215"
