SRCDATE = "20120526"

SRC_URI = "file://quattro-dvb-modules-${SRCDATE}.tar.gz"

require gigablue-dvb-modules.inc

