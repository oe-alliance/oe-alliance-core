DOWNLOADMACHINE = "gb800ue"
PV = "3.1.1"
PR = "r6"

SRCDATE = "20130308"

require gigablue-blindscan-utils.inc

SRC_URI[md5sum] = "d98c2d4cf4bb8c461e486f2ec068172e"
SRC_URI[sha256sum] = "7c0452164ca362b1f19b25669b7890b112b49822ca37f0c9dbe8ece429c1c923"
