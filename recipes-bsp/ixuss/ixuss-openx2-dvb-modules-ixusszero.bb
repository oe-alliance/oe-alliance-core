KV = "3.3.0"
SRCDATE = "20130227"

require ixuss-openx2-dvb-modules.inc

DOWNLOADMACHINE = "zero"

SRC_URI[md5sum] = "b055ebd22e502da6b2229376d708b063"
SRC_URI[sha256sum] = "7f226aff925941e3229ccb25513823c1e026f02edc009e7dd3737980d3267f64"

