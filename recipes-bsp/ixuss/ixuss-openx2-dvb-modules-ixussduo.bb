KV = "3.3.0"
SRCDATE = "20130222"

require ixuss-openx2-dvb-modules.inc

DOWNLOADMACHINE = "one"

SRC_URI[md5sum] = "290132710c388b5b4099b16a560f5047"
SRC_URI[sha256sum] = "d2ed29a4ba712d54825759f903fde2fcb3c6486fd47eb9a43671952979b9f577"

