KV = "3.3.0"
SRCDATE = "20130228"

require ixuss-dvb-modules.inc

SRC_URI[md5sum] = "b8eb7b8e857c1952a101d288e8a6793a"
SRC_URI[sha256sum] = "65a77f3d3d96847f5331adcc684df8bc963dce87523dc25d946283ea36d1c700"

