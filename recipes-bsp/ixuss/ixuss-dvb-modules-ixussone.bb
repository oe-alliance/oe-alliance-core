KV = "3.3.0"
SRCDATE = "20131011"

require ixuss-dvb-modules.inc

DOWNLOADMACHINE = "one"

SRC_URI[md5sum] = "36b79507c3825f8a956265f3a44e6b80"
SRC_URI[sha256sum] = "d7689d6b087241fb549a2f465c41d9463e81ddc9ccf9dd783b5cbee1c75991fc"

