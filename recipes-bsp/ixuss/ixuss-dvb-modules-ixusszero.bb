KV = "3.3.0"
SRCDATE = "20131018"

require ixuss-dvb-modules.inc

DOWNLOADMACHINE = "zero"

SRC_URI[md5sum] = "0db6a8f8fb5803690866b73375089077"
SRC_URI[sha256sum] = "15c8cdf9e7a8a17c39d5bfd2497e09282ac448ccf5d3e753b8fdf2414a172c7a"

