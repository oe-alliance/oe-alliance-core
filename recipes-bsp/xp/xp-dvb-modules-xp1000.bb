KV = "3.5.1"
SRCDATE = "20121129"

require xp-dvb-modules.inc
SRC_URI[md5sum] = "e2280d3e2133c9add609cf808d08388a"
SRC_URI[sha256sum] = "723ed5f346c7b807f21c25708323f176677933303dd33c0fc39aecdd0fcfc986"
