KV = "3.6.0"
SRCDATE = "20140314"

require odin-dvb-modules.inc

SRC_URI[md5sum] = "07688a8b20c88eb0ea561098fd736a94"
SRC_URI[sha256sum] = "f864a1527c8bf06a0e76f153c96ad16469399ceecdd3d5ff77fb63eae2f9dde1"
