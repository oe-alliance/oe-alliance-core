FPVERSION = "15"
FPUPDATE = "1.0"

require odin-fpupdate.inc

SRC_URI[avrmain.md5sum] = "56c1e74eaf019d57fa29e64bb7755023"
SRC_URI[avrmain.sha256sum] = "dca85d2d990f9b718e75b9445ee8d2d2a8851733fd59569c2b4b22045ffa9bc9"

SRC_URI[fpupdate.md5sum] = "cd49ff31cda0c5ede8c346f7963b7042"
SRC_URI[fpupdate.sha256sum] = "46c36e9b4b5a59ca9ea54dcb618ccfeac496b20fcc060cf3e27bf5b7849b7a08"
