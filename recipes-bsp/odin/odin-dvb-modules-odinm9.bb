KV = "3.3.0"
SRCDATE = "20120622"

require odin-dvb-modules.inc

SRC_URI[md5sum] = "82dfdb1f67f92450541ee5887326d4bb"
SRC_URI[sha256sum] = "a28ba7eb7e4f1002eb32fc3b7182c6a3fbd0049c6557f6fbf05aeb7be9050304"
