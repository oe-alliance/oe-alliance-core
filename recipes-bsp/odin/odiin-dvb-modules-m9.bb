KV = "3.3.0"
SRCDATE = "20120517"

require odin-dvb-modules.inc

