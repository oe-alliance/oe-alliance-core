KV = "3.6.0"
SRCDATE = "20140415"

require odin-dvb-modules.inc

SRC_URI[md5sum] = "a43719cbfa830d1b5d2dbe74e07e9c6f"
SRC_URI[sha256sum] = "4c2362efecd22cb0f784f8a861a71a756319e499c86e2a19c359ed006a342ea6"
