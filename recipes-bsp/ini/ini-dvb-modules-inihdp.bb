KV = "3.3.8-2.0"
SRCDATE = "20130717"

SRC_URI[md5sum] = "34eefb7d516b83154a9c6d7d43718536"
SRC_URI[sha256sum] = "3e63103d710972d1b4a1e5edf262cd907215ba0a7d0fd9ca8d80f17714ca8744"

SRC_URI = "http://code-ini.com/software/drivers/ini-hdp-drivers-3.3.8-${SRCDATE}.zip"

require ini-dvb-modules.inc
