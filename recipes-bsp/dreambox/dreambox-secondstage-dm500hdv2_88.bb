require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "f33acf94d6cc34cc23fd9faddadd58ab"
SRC_URI[sha256sum] = "7cfb57fe67d2e259e757ef7bf17ffe95549b12c2752185cba04f038673fdead4"
