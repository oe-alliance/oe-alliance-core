require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "f8e04e19bb570e54f2d2e25056f7ce07"
SRC_URI[modules.sha256sum] = "63c878c431bb67f548a4b92337ad4ce88606d4d69fdb9dc04a0a6ee0f4077c98"