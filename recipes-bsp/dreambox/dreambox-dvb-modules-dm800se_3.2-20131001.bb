require dreambox-dvb-modules.inc

PR = "${INC_PR}.1"

SRC_URI[modules.md5sum] = "9edc9c62e38496297b640514f8941db9"
SRC_URI[modules.sha256sum] = "0d265b728799bab4e5f859538ad85c6bab407312829285a80234f7f30228f8d2"


