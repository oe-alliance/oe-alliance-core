require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "f7d61fa8218df3a90303cd8413e32027"
SRC_URI[modules.sha256sum] = "d07667da19128f8938e2f644b057a83d33ceabc33847c00c10f042010bcb93de"
