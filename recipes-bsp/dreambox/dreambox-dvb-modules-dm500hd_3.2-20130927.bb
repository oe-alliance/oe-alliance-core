require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "a5950f9233d6abf4f966a32d6c9f8753"
SRC_URI[modules.sha256sum] = "1c5ed65a21c8cd9bf40e8e21cb12404d28988aca16f2b81686f22f32efa259c6"
