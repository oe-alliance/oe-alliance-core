require dreambox-dvb-modules.inc

PR = "${INC_PR}.1"

SRC_URI[modules.md5sum] = "9d5a12e2d730aea873cdbf0248e027d9"
SRC_URI[modules.sha256sum] = "6a04db915a85f29da466290828f1719b7b6b2cd73648126f451badc919bf7b28"


