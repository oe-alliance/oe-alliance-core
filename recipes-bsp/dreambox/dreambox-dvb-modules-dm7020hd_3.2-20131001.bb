require dreambox-dvb-modules.inc

PR = "${INC_PR}.3"

SRC_URI[modules.md5sum] = "a12b9bebc568396e9a28e83d10c5076c"
SRC_URI[modules.sha256sum] = "101e7e355c409370b82c9407e775b955dfac5df42fd55b7de69f4e09ba06044a"
