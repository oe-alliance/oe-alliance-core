require recipes-bsp/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "2a9d3369c7fd5e9db101d3c86d98f5bf"
SRC_URI[modules.sha256sum] = "1b28f779b00f7f0d9cf25940e05e789d0610ecbf990a13c2e44d2d19ae562e43"
