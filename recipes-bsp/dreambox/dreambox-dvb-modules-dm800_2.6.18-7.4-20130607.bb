require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "07fe648e591452df167053abb85f6c80"
SRC_URI[modules.sha256sum] = "21cc63b78ecfdbe05c55e5ff571cc565f855b0c3643e6b9ec09f793b6e8f0eb7"

#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
