require recipes-bsp/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "6e798d35d2c4f2bb508d8f783d633f50"
SRC_URI[modules.sha256sum] = "1cd530a87e92431bc6f8c55c32da790072b090c2c72068838c5aa7dd7812c81b"
