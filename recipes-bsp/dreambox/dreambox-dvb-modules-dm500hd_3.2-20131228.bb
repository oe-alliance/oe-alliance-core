require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "80e46bd4f589c5b28d84b7a659fb6c21"
SRC_URI[modules.sha256sum] = "7799834aa8d16d586826f49fff6a48dd126f6b2b1d517573dfa992abbb8d7bdb"
