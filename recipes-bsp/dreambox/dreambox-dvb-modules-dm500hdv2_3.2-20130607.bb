require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "feaa5d53299f2513caec4d2db3a61b54"
SRC_URI[modules.sha256sum] = "086ab1a368bda0f6ce94d72e211cd843969e44f23ad8499ef28b4f5f1a9797c0"
