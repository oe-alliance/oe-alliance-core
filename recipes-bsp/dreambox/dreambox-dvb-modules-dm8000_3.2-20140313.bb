require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "78f441da1583521392da2b705e519418"
SRC_URI[modules.sha256sum] = "7af742c56b9b5dafa011861a873838f7eb85b82b7c77162e1198c25bd86f925a"