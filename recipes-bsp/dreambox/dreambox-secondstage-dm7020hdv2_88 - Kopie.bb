require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "f94311bd02c5dbdb663bd4cd1ae43a26"
SRC_URI[sha256sum] = "ad30234d18a308cf986fb3685e3a3a520a0f12b83234ac4f569b4dc557d521de"
