require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "8f64b99bf4b84c77e84aa6ec267f4776"
SRC_URI[modules.sha256sum] = "e1657cf57f2806b0d0a75f2adbf921403403edae1c0a181706547a878a8bbfc4"
