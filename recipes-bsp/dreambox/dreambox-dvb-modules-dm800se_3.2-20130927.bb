require dreambox-dvb-modules.inc

PR = "${INC_PR}.1"

SRC_URI[modules.md5sum] = "fd5037a91804c227c78bb97200e28a71"
SRC_URI[modules.sha256sum] = "72614125b0156f65834d21efd016896d57341756d24ec84b1da4235e4cb849f0"


