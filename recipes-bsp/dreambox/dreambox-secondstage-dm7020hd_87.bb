require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "aee2729d37be2ae1e8070e8327f50f06"
SRC_URI[sha256sum] = "fb318ce22a9b5cbe1eaf8551b7a43593266e046deded4048f397c95f646c93d8"
