require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "39f104321e21bdbbc1eb9e2fb65d20f2"
SRC_URI[modules.sha256sum] = "12731073b4dd2dfd374f75c69cc71eae3316add28dd2ac8374522470a28cadf9"
