require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "480a50974219da621b2fd60df9ed57b2"
SRC_URI[sha256sum] = "d39aa9ed41241f9604cf5cbc90ba6df978e7419d5041068ed6194fd92f1f3916"
