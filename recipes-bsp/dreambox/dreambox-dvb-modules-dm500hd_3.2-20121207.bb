require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "64108c13f392b8fd6b479b44c09d8bfd"
SRC_URI[modules.sha256sum] = "8d38e7316b3817c9cc63af29f5b4e28367ab60ea500d540e5d78c2e6cf6bff30"
