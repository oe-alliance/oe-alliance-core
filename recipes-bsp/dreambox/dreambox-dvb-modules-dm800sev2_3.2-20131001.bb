require dreambox-dvb-modules.inc

PR = "${INC_PR}.2"

SRC_URI[modules.md5sum] = "d0c7fe8ee43405e7ae5cc1672803b977"
SRC_URI[modules.sha256sum] = "0941fbd22deb5aa60ec1db8d4d34512caf3156c90d5ee81d0ce8b70e78ea800c"


