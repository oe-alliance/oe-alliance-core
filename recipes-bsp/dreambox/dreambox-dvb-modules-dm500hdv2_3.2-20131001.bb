require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "c610ff233018f9b07fda859073559859"
SRC_URI[modules.sha256sum] = "d0bd78c9722141d2d892a1e9e21f5851011fccde3428bff21e224dcca199febc"
