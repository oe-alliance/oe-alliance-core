require dreambox-dvb-modules.inc

PR = "${INC_PR}.3"

SRC_URI[modules.md5sum] = "cd7ca4a1a7587b0b5f891fb56f105e6b"
SRC_URI[modules.sha256sum] = "96bd80a0f519b49528c7c4996c83959507503adf60a12081b65c46186975328c"
