KV = "3.4.3"
SRCDATE = "20121029"

require mara-dvb-modules.inc

SRC_URI[md5sum] = "9fcc94f27284fc863c2e34273ea45d9a"
SRC_URI[sha256sum] = "48ff8db283431277725ef114610b93263df76749045b7e5678ca35b1c93da3a2"
