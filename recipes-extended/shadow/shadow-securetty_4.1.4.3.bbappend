PRINC = "1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
