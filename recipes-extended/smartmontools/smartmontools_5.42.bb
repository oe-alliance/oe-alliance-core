PR = "${INC_PR}.0"

SRC_URI[md5sum] = "4460bf9a79a1252ff5c00ba52cf76b2a"
SRC_URI[sha256sum] = "b664d11e814e114ce3a32a4fa918c9e649c684e2897c007b2a8b92574decc374"

require smartmontools.inc
