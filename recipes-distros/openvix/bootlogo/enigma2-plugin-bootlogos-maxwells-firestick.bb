SUMMARY = "Maxwell fire stick bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r0"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_FireStick.zip"

SRC_URI[md5sum] = "477cc64e7509a014cf5818653deb1066"
SRC_URI[sha256sum] = "278810c2447b52a1c9033b5d303e3c20fb7a084f3920f30d1ca656f36e172fcb"
