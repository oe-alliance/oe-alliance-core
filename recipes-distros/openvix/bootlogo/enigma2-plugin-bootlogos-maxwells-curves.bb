SUMMARY = "Maxwell curves bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r0"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_curves.zip"

SRC_URI[md5sum] = "0570b7ba77e58f769eb2568c189a69fe"
SRC_URI[sha256sum] = "44cae333e1fb6cc9f3ee65b2695e836075b059bd4633caf51c3bbfddac4643fc"
