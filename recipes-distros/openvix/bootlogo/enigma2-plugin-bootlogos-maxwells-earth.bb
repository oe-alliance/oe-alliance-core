SUMMARY = "Maxwell earth bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r0"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_Earth.zip"

SRC_URI[md5sum] = "fd6bf848863a636316fbcdc11e791661"
SRC_URI[sha256sum] = "a6b99ce13f9987bb41dfb76f9f70747a088a54da09be8831806fe02d456769bc"
