SUMMARY = "Maxwell river bootlogo"

require recipes-oe-alliance/bootlogo/bootlogos.inc

PV = "1.0"
PR = "r0"

SRC_URI = "http://enigma2.world-of-satellite.com/bootlogos/Maxwells_River.zip"

SRC_URI[md5sum] = "04bca4b298c8fcd64ff63e07480784ed"
SRC_URI[sha256sum] = "9b74e9c26ac7efb60cbfae3001322fca23ae2a424e2a78a54a01d5ca99e0a153"
