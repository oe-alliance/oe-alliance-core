require libungif_${PV}.bb

S = "${WORKDIR}/libungif-${PV}"

PACKAGES = ""

inherit autotools native
