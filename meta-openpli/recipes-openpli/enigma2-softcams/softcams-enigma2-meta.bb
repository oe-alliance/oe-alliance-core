DESCRIPTION = "meta file for enigma2 softcam packages"

require conf/license/openpli-gplv2.inc

PROVIDES = "softcams"

DEPENDS = "\
	enigma2-plugin-softcams-cccam \
	enigma2-plugin-softcams-cccam209 \
	enigma2-plugin-softcams-cccam221 \
	enigma2-plugin-softcams-mgcamd \
	enigma2-plugin-softcams-evocamd \
	enigma2-plugin-softcams-newcs \
	enigma2-plugin-softcams-oscam-stable \
	enigma2-plugin-softcams-oscam-unstable \
	enigma2-plugin-softcams-oscam-experimental \
	enigma2-plugin-softcams-oscam-stable-cs \
	enigma2-plugin-softcams-oscam-unstable-cs \
	enigma2-plugin-softcams-oscam-experimental-cs \
	enigma2-plugin-softcams-rqcamd \
	enigma2-plugin-softcams-scam \
	"
