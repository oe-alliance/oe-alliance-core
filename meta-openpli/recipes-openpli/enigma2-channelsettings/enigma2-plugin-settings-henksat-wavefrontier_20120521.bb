DESCRIPTION = "Henksat Wavefrontier"

SETTINGS_FILENAME = "henksat_wavefrontier_e2"

include henksat.inc

SRC_URI[md5sum] = "4c08de4b1a367e69449f2bb77e7c300f"
SRC_URI[sha256sum] = "cc75e181b18700b3198a973bd7ad6ed56260d49ae456aa6128327bba300e7e13"
