DESCRIPTION = "Henksat 19E,23E"

SETTINGS_FILENAME = "henksat_astra_1_3_e2"

include henksat.inc

SRC_URI[md5sum] = "fb7d3173b7e0dd31218caf426add26ec"
SRC_URI[sha256sum] = "0dc8d400aa5ddaa48c1b9fd0641cf2ffbe6d4e79c73ee08b13f5d3074ae4a3a5"
