SATNAMES = "Motor"

require rytec-settings.inc

S = "${WORKDIR}/Rytec_E2_${SATNAMES}_${PV}"

SRC_URI[md5sum] = "43090fd07c462f1fafb51eccc1a83ba5"
SRC_URI[sha256sum] = "ece3682e68dcbf8caf02f3d60e42a15fdd61c8552f94f4909645f2539f24a9c0"
