DESCRIPTION = "Henksat 19E,23E,28E"

SETTINGS_FILENAME = "henksat_full_astra_1_2_3_e2"

include henksat.inc

SRC_URI[md5sum] = "321e9e37399035ccc8e8bfad24310716"
SRC_URI[sha256sum] = "e02f96540275d222bcff29e8f4dfe0f32d64db1be764d5201211b16e4e69a036"
