DESCRIPTION = "Henksat 13E,19E,23E,28E,4.8E,0.8W"

SETTINGS_FILENAME = "henksat_astra_1_2_3_hb_sirius_thor_e2"

include henksat.inc

SRC_URI[md5sum] = "59844a8c7b7377e501093c45a773d060"
SRC_URI[sha256sum] = "6eb582eb1c400ea600fd82a49fe6cafb17d8cc51f93490af65a71fd1acead254"
