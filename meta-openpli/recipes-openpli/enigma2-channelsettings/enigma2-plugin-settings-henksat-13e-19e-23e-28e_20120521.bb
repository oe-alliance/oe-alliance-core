DESCRIPTION = "Henksat 13E,19E,23E,28E"

SETTINGS_FILENAME = "henksat_astra_1_2_3_hb_e2"

include henksat.inc

SRC_URI[md5sum] = "e615c395d630e9fe7aae2cf52aa63bde"
SRC_URI[sha256sum] = "a805d7d7ed6100b4ff33f4ba5bad18c0e6fb9d418976919a6e714c008e79074a"
