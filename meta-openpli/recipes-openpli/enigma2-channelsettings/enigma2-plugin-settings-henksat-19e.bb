DESCRIPTION = "Henksat 19E"

SETTINGS_FILENAME = "e2_henksat_astra_1"

include henksat.inc
