DESCRIPTION = "Henksat Alatas 7E,13E,19E,23E,28E,42E"

SETTINGS_FILENAME = "henksat_alatas_astra_1_2_3_hb_42e_7e_e2"

include henksat.inc

SRC_URI[md5sum] = "31f27f17b115f760f2c530e52b6f59d8"
SRC_URI[sha256sum] = "d72435fa8fb7c275a291eb37f731f221e8732f1e20ba70f9b1107d7de3ec7d4a"