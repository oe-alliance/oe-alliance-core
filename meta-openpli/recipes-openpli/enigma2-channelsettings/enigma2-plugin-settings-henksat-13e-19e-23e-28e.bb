DESCRIPTION = "Henksat 13E,19E,23E,28E"

SETTINGS_FILENAME = "e2_henksat_astra_1_2_3_hb"

include henksat.inc
