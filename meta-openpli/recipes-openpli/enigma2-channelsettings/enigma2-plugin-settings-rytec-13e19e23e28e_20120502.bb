SATNAMES = "13e19e23e28e"

require rytec-settings.inc

S = "${WORKDIR}/Rytec_E2_${SATNAMES}_${PV}"

SRC_URI[md5sum] = "6fa2abc2f37dd3921bfa1c9583f1c938"
SRC_URI[sha256sum] = "315c8f4e0c05e5845dc03ee39ee48f41c7db2d00795295ec55e26d76dd3ad3ab"
