DESCRIPTION = "Henksat 19E,23E"

SETTINGS_FILENAME = "e2_henksat_astra_1_3"

include henksat.inc
