DESCRIPTION = "Henksat Rotating (45.0e-45.0w)"

SETTINGS_FILENAME = "henksat_rotating_45e_45w_e2"

include henksat.inc

SRC_URI[md5sum] = "89b3790f1b85ff13126ca50ef184ab4b"
SRC_URI[sha256sum] = "1f22b215ad5482963a4c97bfb43494798a204d2976b6fb43bacaceca3671701f"