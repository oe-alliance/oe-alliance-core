DESCRIPTION = "Henksat 19E,23E,28E"

SETTINGS_FILENAME = "henksat_full_astra_1_2_3_e2"

include henksat.inc

SRC_URI[md5sum] = "95bd72dcb2aa336659e9adb1cb1b397b"
SRC_URI[sha256sum] = "907b713c18ac28c4ec9a724da9dfecac5798c135b504d35c477caaf7dbc0d877"
