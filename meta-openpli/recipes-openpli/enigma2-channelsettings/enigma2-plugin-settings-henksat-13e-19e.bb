DESCRIPTION = "Henksat 13E,19E"

SETTINGS_FILENAME = "e2_henksat_astra_1_hb"

include henksat.inc
