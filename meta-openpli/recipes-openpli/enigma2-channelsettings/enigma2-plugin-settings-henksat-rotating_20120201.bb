DESCRIPTION = "Henksat Rotating (45.0e-45.0w)"

SETTINGS_FILENAME = "henksat_rotating_45e_45w_e2"

include henksat.inc

SRC_URI[md5sum] = "398ce634ba4668f7478445f31930a86a"
SRC_URI[sha256sum] = "3a88c49d60a564d07fbbeb8e12bf765f1380fc96c6073259860501002d1ffbbb"