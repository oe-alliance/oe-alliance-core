DESCRIPTION = "Henksat 19E,23E"

SETTINGS_FILENAME = "henksat_astra_1_3_e2"

include henksat.inc

SRC_URI[md5sum] = "62f089b41cfffde67b81781972e0f51c"
SRC_URI[sha256sum] = "6b466c50620d2b2f78bfa75f3ef3787d44b339144d8e4722736a802ed2d27cdb"
