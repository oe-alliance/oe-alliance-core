DESCRIPTION = "Henksat 13E,19E"

SETTINGS_FILENAME = "henksat_astra_1_hb_e2"

include henksat.inc

SRC_URI[md5sum] = "004b681c162eb0c8d4aff4dfe51962c7"
SRC_URI[sha256sum] = "c3e0becf1cfd9d38a10bdf44d052d02e876db9186e741f61bb7cb131868ff1b8"