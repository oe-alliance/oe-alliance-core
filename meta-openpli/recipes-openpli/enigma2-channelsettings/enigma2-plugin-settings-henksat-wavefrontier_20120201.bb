DESCRIPTION = "Henksat Wavefrontier"

SETTINGS_FILENAME = "henksat_wavefrontier_e2"

include henksat.inc

SRC_URI[md5sum] = "1c3c7a30e3ad757d3fbd3dee5ea1b2d7"
SRC_URI[sha256sum] = "84d4c7d345d469ce74ded69b905398b03f81e041e4107d8a42bfa93a0b6ab752"
