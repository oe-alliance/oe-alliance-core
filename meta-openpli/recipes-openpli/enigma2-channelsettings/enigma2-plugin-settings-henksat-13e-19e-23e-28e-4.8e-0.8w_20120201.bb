DESCRIPTION = "Henksat 13E,19E,23E,28E,4.8E,0.8W"

SETTINGS_FILENAME = "henksat_astra_1_2_3_hb_sirius_thor_e2"

include henksat.inc

SRC_URI[md5sum] = "d329adb119212b1e8cd7cde523925ef6"
SRC_URI[sha256sum] = "e68d97c8a15d5e2f21f1cb7e06acefff71e37fbbb572d62602d91766bb68f483"
