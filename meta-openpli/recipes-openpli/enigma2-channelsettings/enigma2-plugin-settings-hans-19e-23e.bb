DESCRIPTION = "Hans 19E,23E"

SETTINGS_FILENAME = "e2_hanssettings_astra_19_23"

include hans.inc
