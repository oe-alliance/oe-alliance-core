DESCRIPTION = "Henksat 19E"

SETTINGS_FILENAME = "henksat_astra_1_e2"

include henksat.inc

SRC_URI[md5sum] = "388ffde09f3997ad5720239a2b2e5ac4"
SRC_URI[sha256sum] = "ef6fb2a7aece5cb29be4e76426e0e309ed42d7a7736b247577e56476dc7a6b42"
