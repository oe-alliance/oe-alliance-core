DESCRIPTION = "Henksat 13E,19E,23E,28E"

SETTINGS_FILENAME = "henksat_astra_1_2_3_hb_e2"

include henksat.inc

SRC_URI[md5sum] = "85595ed617c2d4546f6170014d3004ce"
SRC_URI[sha256sum] = "7e62d63dee62641c9a729dd4f5530c3bfbd7bd305a12c393492b0c1c22ab01b7"
