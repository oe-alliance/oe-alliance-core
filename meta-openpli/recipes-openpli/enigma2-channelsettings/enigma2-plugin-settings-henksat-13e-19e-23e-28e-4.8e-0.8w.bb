DESCRIPTION = "Henksat 13E,19E,23E,28E,4.8E,0.8W"

SETTINGS_FILENAME = "e2_henksat_astra_1_2_3_hb_sirius_thor"

include henksat.inc
