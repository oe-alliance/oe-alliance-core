DESCRIPTION = "Henksat 19E"

SETTINGS_FILENAME = "henksat_astra_1_e2"

include henksat.inc

SRC_URI[md5sum] = "447851d757030d8caa3acf4726846cc0"
SRC_URI[sha256sum] = "da901e1848d77802be2d836879661a7c0a605e3535dd0e90287ce09c75a276ff"
