DESCRIPTION = "Hans 13E,19E,23E,28E and rotating"

SETTINGS_FILENAME = "e2_hanssettings_astra_19_23_28_hb_rotating"

include hans.inc
