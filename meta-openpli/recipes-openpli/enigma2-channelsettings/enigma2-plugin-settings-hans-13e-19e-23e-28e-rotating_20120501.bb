DESCRIPTION = "Hans 13E,19E,23E,28E and rotating"

SETTINGS_FILENAME = "hans_13e_19e_23e_28e_and_rotating_e2"

include hans.inc

SRC_URI[md5sum] = "217551cc071b15ef3228d18cb17b02bf"
SRC_URI[sha256sum] = "f4f97c1c084b1926cf007ef1d00b17694d6b5ed5bed961adcb657713a643b94e"
