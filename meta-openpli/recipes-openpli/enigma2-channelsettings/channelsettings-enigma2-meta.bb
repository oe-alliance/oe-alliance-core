require conf/license/openpli-gplv2.inc

DESCRIPTION = "meta file for settings"

DEPENDS = "\
	enigma2-plugin-settings-henksat-19e \
	enigma2-plugin-settings-henksat-13e-19e \
	enigma2-plugin-settings-henksat-19e-23e \
	enigma2-plugin-settings-henksat-19e-23e-28e \
	enigma2-plugin-settings-henksat-13e-19e-23e-28e \
	enigma2-plugin-settings-henksat-wavefrontier \
	enigma2-plugin-settings-henksat-rotating \
	enigma2-plugin-settings-henksat-7e-13e-19e-23e-28e-42e \
	enigma2-plugin-settings-henksat-13e-19e-23e-28e-4.8e-0.8w \
	enigma2-plugin-settings-ziggo-casema-west \
	enigma2-plugin-settings-hans-19e-23e \
	enigma2-plugin-settings-hans-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-13e-19e-23e-28e-rotating \
	enigma2-plugin-settings-rytec-13e19e23e28e \
	enigma2-plugin-settings-rytec-motor \
	"

PR = "r0"
