DESCRIPTION = "Hans 13E,19E,23E,28E"

SETTINGS_FILENAME = "e2_hanssettings_astra_19_23_28_hb"

include hans.inc
