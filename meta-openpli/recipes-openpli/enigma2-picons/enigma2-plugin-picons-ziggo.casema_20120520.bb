PICON_SATNAMES = "ziggo.casema"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-casema-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "c63f9c17348ed6a547f8b5e5f87cf2a1"
SRC_URI[sha256sum] = "170386f3e8ecf095abbae884f54796f0bd2150208c5617ea9badf41b08585a70"