# meta package for enigma2 picon sets

require conf/license/openpli-gplv2.inc

DEPENDS = " \
		enigma2-plugin-picons-sat \
		enigma2-plugin-picons-ziggo.tvhome \
		enigma2-plugin-picons-ziggo.casema \
		"