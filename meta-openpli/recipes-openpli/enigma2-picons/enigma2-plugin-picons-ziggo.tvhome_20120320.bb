PICON_SATNAMES = "ziggo.tvhome"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-tvhome-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "a0420bbeeea80899e8bb648d1eac6e35"
SRC_URI[sha256sum] = "d3b9a983fbe52316b8957e2842e5c672bd5895ca233cf70b30de7538d0504d03"
