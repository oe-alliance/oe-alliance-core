PRINC = "1"

SRC_URI += "file://sanity-check-provides.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"