SRCDATE = "20120126"

PR = "r1"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"

SRC_URI[md5sum] = "bb0761153f971f3aa7bd55f25336930e"
SRC_URI[sha256sum] = "3e63993017ce95dfe5ebed7e55b592bdd3a7a2cb872ef08fd0d624f33fb92aaa"
