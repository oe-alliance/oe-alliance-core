SRCDATE = "20120126"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"

SRC_URI[md5sum] = "c8d3556014d3324854ec9161ea1fc8c3"
SRC_URI[sha256sum] = "7f858e51f71c5f41887953d9a769cdfd68c31173a40bc5db8371ef0c96976728"
