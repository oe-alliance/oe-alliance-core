require vuplus-blindscan-utils.inc

SRC_URI[md5sum] = "3da86d706f0686bfd88793de4db2e1bd"
SRC_URI[sha256sum] = "a5f62c990c64ce5fabdcc3e21ee5b855e25b1cea2bad85c7f1585f2ff6c34b
