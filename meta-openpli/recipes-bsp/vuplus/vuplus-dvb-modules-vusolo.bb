SRCDATE = "20120126"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"

SRC_URI[md5sum] = "b989e711488c240b755c5d6c20a34490"
SRC_URI[sha256sum] = "d84da8f3bbad0a368748ed3689a1b898e5d3e45f1557f7ce3c5886946b1e0b71"
