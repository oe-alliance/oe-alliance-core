require vuplus-blindscan-utils.inc

SRC_URI[md5sum] = "72012c43c1cc0592f9330fc4d96c54a9"
SRC_URI[sha256sum] = "2e036147f5376ddb0b752603bbdfa5a142e4689e08bbe2478142b298fc151140"
