SRCDATE = "20120126"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "bm750"

SRC_URI[md5sum] = "798f971c2bce6141b5f73e411a982ece"
SRC_URI[sha256sum] = "bc467b3272e758142745f7497c0c7f3d3b14a00a687f98aa3649839e5b4f507e"
