KV = "3.3.0"
SRCDATE = "20120331"

require et-dvb-modules.inc

SRC_URI[md5sum] = "1986366e1b5b5c430e634f0fe6cd150d"
SRC_URI[sha256sum] = "043452fdd04a8165a0edce9cbad7f08f6fbb5a68410a5ce06797cf04e5d83f3a"
