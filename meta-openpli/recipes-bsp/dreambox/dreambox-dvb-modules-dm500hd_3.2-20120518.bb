require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "21ea282515733e97616be43d149c0322"
SRC_URI[modules.sha256sum] = "31b5f7612d5ea229a72cc082c439187e064fc523ef5af99a2ff3b06391afef1a"
