require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "768a0bab6ce70157ee1ff0ea5d1d298a"
SRC_URI[modules.sha256sum] = "0fb2d0b657efaea3a67d7600fd40b336dc0abcf6577297cb54aa70c8eeb17c3e"
