require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "d13c2713f4062a7de53f02f6ae8dba48"
SRC_URI[sha256sum] = "4280e588f85689fca109aeeabd54a98e22674ce0f98fb10c23878d72de54a227"
