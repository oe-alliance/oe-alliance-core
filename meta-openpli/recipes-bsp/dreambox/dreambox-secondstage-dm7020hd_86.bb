require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "51d43de794388a0fc07a6b4a3392d6d6"
SRC_URI[sha256sum] = "203bc73ee14a71f7b94229185e34886eece566d5a6aa6540b1cf434bbcb61d84"
