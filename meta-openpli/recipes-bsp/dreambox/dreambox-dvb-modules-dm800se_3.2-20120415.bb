require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "826b8fd26d97a33d63210acb273cec64"
SRC_URI[modules.sha256sum] = "d212bc96b993263126b1fabc71dee0faafab8abd769d5899fc07f5a4ee3919b7"
