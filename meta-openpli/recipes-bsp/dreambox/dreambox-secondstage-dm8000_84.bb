require dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "8a6d83a266f88ec8fa5d130083f46d25"
SRC_URI[sha256sum] = "b5dbfe00674e8dea38b5069b1bfde3fe6b4486d4c4556ac775b3127e8454ca98"
