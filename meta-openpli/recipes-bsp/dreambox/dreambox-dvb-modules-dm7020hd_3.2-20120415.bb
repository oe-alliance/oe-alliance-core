require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "44bc0ec09808e0bff00ef4a098774e57"
SRC_URI[modules.sha256sum] = "df35361c21849cb44084b1122342d1f4893dda9bf3ab2ce3de0efa1e0bedb0f2"
