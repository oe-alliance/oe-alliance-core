PRINC = "1"

SRC_URI = "git://git.assembla.com/openvix.14.git;protocol=git"

