SUMMARY = "meta file for enigma2 DVD writing support"
require conf/license/license-gplv2.inc
DEPENDS = "\
    mjpegtools \
    dvdauthor \
    replex \
    cdrkit \
    dvd+rw-tools \
    "
