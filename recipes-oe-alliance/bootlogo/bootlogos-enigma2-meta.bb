DESCRIPTION = "meta file for bootlogos"

require conf/license/license-gplv2.inc

DEPENDS = "\
	"

PR = "r0"
