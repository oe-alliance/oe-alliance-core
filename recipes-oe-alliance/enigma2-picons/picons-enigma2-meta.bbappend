PACKAGE_ARCH = "all"

DEPENDS += " \
    enigma2-plugin-picons-tv-sgtflipflop.28e \
    enigma2-plugin-picons-tv-sandman.28e \
    "