# meta package for enigma2 picon sets

require conf/license/license-gplv2.inc

PACKAGE_ARCH = "all"

PR = "r5"

DEPENDS = " \
		enigma2-plugin-picons-sat \
		enigma2-plugin-picons-ziggo.tvhome \
		enigma2-plugin-picons-ziggo.casema \
		enigma2-plugin-picons-tv-sgtflipflop.28e \
		enigma2-plugin-picons-tv-sandman.28e \
		"