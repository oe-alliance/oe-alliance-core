PICON_SATNAMES = "ziggo.tvhome"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-tvhome-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "7a32e0c0f188d5fdbe4bba321f152bdf"
SRC_URI[sha256sum] = "9f05dd4a3242b4ef3cf5342a81f6e364f823352d9fa8479ee5530f0a42ce7b90"
