MODULE = "ScreenPosition"
DESCRIPTION = "Adjust the screen position"
PACKAGE_ARCH = "${MACHINE_ARCH}"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
