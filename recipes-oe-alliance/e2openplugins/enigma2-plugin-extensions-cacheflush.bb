MODULE = "CacheFlush"
DESCRIPTION = "periodicaly flushing cache"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
