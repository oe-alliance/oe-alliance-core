MODULE = "XPower"
DESCRIPTION = "remote PC power management for win and linux"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
