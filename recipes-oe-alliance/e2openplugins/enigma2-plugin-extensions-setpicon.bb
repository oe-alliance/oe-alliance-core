MODULE = "SetPicon"
DESCRIPTION = "Work with services picons"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
