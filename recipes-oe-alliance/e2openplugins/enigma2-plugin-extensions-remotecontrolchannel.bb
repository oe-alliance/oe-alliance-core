MODULE = "RemoteControlChannel"
DESCRIPTION = "Remote control ir channel selection"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
