MODULE = "AntiLogo"
DESCRIPTION = "Prevent logo retention"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
