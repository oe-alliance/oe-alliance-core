MODULE = "MeteoViewer"
DESCRIPTION = "meteo pictures viewer"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
