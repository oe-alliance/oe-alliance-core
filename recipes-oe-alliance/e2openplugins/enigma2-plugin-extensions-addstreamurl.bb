MODULE = "AddStreamUrl"
DESCRIPTION = "Add a stream url to your channellist"

PR="r0"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
