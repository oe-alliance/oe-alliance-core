PRINC = "2"

DEPENDS += "\
	enigma2-plugin-drivers-dvb-usb-af9035 \
	enigma2-plugin-drivers-dvb-usb-a867 \
	"

