PRINC = "1"

RDEPENDS_${PN} += " \
	${DVBPROVIDER}-module-tda10071 \
	"
