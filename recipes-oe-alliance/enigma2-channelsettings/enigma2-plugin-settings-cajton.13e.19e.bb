DESCRIPTION = "Cajton E2 Settings File For 13e & 19e"
PV = "20120225"

SETTINGS_FILENAME = "cajton.13e.19e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "74a1ef08d3d2ef310721f2762e6e7ea5"
SRC_URI[sha256sum] = "39c3b0f75e90b81c100f309931672c717266e4b0d911e382df4f1697065eba54"
