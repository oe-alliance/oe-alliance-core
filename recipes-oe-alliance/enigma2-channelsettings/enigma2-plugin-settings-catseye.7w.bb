DESCRIPTION = "Catseye E2 Settings File For 7w"

SETTINGS_FILENAME = "catseye.7w"

include oe-alliance-settings.inc
