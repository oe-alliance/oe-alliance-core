DESCRIPTION = "Don@ E2 Settings File For 23E+19E+13E"

SETTINGS_FILENAME = "dona.multifeed.23e.19e.13e"

include oe-alliance-settings.inc
