DESCRIPTION = "Predr@d  28e , 30w"

SETTINGS_FILENAME = "predrag.28e.30w"

include oe-alliance-settings.inc
