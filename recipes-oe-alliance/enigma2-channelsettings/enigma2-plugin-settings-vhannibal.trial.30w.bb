DESCRIPTION = "Vhannibal E2 Settings File Trial 30w"

SETTINGS_FILENAME = "vhannibal.trial.30w"

include oe-alliance-settings.inc
