DESCRIPTION = "Vhannibal E2 Settings File For HotBird"

SETTINGS_FILENAME = "vhannibal.hotbird"

include oe-alliance-settings.inc
