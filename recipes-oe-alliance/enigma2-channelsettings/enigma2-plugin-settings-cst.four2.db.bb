DESCRIPTION = "CST Four2 E2 Settings File"

SETTINGS_FILENAME = "cst.four2.db"

include oe-alliance-settings.inc
