DESCRIPTION = "Malimali 13E Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.13e"

include oe-alliance-settings.inc
