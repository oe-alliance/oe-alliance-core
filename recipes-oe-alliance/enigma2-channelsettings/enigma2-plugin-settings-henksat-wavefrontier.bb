DESCRIPTION = "Henksat Wavefrontier"

SETTINGS_FILENAME = "e2_henksat_wavefrontier"

include henksat.inc
