DESCRIPTION = "B16MCC E2 HD Swap Settings File For 28e"

SETTINGS_FILENAME = "b16mcc.hd.swap.28e"

include oe-alliance-settings.inc
