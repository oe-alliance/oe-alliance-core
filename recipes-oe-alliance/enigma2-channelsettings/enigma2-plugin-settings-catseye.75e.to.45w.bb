DESCRIPTION = "Catseye E2 Settings File For 75E - 45W"

SETTINGS_FILENAME = "catseye.75e.to.45w"

include oe-alliance-settings.inc
