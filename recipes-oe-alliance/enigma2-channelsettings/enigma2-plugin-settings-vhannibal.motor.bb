DESCRIPTION = "Vhannibal Motor E2 Settings File"
PV = "20120306"

SETTINGS_FILENAME = "vhannibal.motor"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "2afdb9484f74e149bbef4db48a29d658"
SRC_URI[sha256sum] = "5675fa602fa48439fdec9cc7249bd020c293194d7d5378172354f0e492685f26"
