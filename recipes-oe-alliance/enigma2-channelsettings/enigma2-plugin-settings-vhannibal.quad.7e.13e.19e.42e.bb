DESCRIPTION = "Vhannibal E2 Settings File For 7e, 13e, 19e & 42e"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.quad.7e.13e.19e.42e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "593167b1fe04d30bfc55e7850630cc83"
SRC_URI[sha256sum] = "dea9961f9d249c1e6b2aa0a87bede56df0593f9427317d800c5f946b0ccc4985"
