DESCRIPTION = "Don@ E2 Settings File For 28E+23E+19E+16E+13E+9E+7E+5E+1W"

SETTINGS_FILENAME = "dona.multifeed.28e.23e.19e.16e.13e.9e.7e.5e.1w"

include oe-alliance-settings.inc
