DESCRIPTION = "Swallow 19e E2 Settings File"

SETTINGS_FILENAME = "swallow.19e"

include oe-alliance-settings.inc
