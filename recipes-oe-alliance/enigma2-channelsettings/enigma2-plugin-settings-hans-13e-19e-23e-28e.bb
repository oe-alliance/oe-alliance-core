DESCRIPTION = "Hans 13E,19E,23E,28E"

SETTINGS_FILENAME = "e2_hanssettings_13e_19e_23e_28e"

include hans.inc
