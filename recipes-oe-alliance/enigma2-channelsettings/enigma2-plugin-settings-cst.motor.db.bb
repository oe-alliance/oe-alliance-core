DESCRIPTION = "CST Motor E2 Settings File"

SETTINGS_FILENAME = "cst.motor.db"

include oe-alliance-settings.inc
