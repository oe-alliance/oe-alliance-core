DESCRIPTION = "Vhannibal E2 Settings File For Dual Feeds & DTT Napoli"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.dual.feeds.dtt.napoli"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "45ffd786edb2576cb9f7b7d31db17e68"
SRC_URI[sha256sum] = "c02987433e95ddc120fb0589add703ebc4ef550624d87b1d792ff1c3aeecfb7f"
