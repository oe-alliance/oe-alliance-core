DESCRIPTION = "CST Five.2 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.five.2.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "6ddf6abd41c5c8f99c42928b9790b6a2"
SRC_URI[sha256sum] = "c67e02ae84e63cdeef3c561fcac97622e7ce8854de113e1e0616d61c48c43589"
