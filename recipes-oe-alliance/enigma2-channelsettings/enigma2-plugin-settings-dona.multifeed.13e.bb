DESCRIPTION = "Don@ E2 Settings File For 13E"

SETTINGS_FILENAME = "dona.multifeed.13e"

include oe-alliance-settings.inc
