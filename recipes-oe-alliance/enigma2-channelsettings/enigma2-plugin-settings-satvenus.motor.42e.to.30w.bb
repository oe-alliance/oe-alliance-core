DESCRIPTION = "Satvenus E2 Settings File For Motor 42E to 30W"

SETTINGS_FILENAME = "satvenus.motor.42e.to.30w"

include oe-alliance-settings.inc
