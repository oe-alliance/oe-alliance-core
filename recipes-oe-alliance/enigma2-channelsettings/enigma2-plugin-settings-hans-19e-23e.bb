DESCRIPTION = "Hans 19E,23E"

SETTINGS_FILENAME = "e2_hanssettings_19e_23e"

include hans.inc
