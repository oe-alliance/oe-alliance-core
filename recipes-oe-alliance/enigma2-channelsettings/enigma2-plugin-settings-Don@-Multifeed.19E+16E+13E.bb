DESCRIPTION = "Don@ E2 Settings File For 19E+16E+13E"

SETTINGS_FILENAME = "Don@-Multifeed.19E+16E+13E"

include oe-alliance-settings.inc
