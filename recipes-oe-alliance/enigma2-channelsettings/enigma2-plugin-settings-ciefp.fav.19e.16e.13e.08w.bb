DESCRIPTION = "Ciefp E2 Settings File For 19e, 16e, 13e & 08w"

SETTINGS_FILENAME = "ciefp.fav.19e.16e.13e.08w"

include oe-alliance-settings.inc
