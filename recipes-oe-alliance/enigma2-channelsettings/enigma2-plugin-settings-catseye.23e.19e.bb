DESCRIPTION = "Catseye E2 Settings File For 23.5E 19.2E"

SETTINGS_FILENAME = "catseye.23e.19e"

include oe-alliance-settings.inc
