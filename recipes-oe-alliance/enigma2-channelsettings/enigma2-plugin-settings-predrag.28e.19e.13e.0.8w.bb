DESCRIPTION = "Predr@d 28e ,19e ,13e, 0.8w"

SETTINGS_FILENAME = "predrag.28e.19e.13e.0.8w"

include oe-alliance-settings.inc
