DESCRIPTION = "Satvenus E2 Settings File For 28e.23e.19e.16e.13e.9e.7e.5e.1w"

SETTINGS_FILENAME = "satvenus.28e.23e.19e.16e.13e.9e.7e.5e.1w"

include oe-alliance-settings.inc
