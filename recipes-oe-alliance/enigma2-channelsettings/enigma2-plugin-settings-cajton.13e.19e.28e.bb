DESCRIPTION = "Cajton E2 Settings File For 13e, 19e & 28e"

SETTINGS_FILENAME = "cajton.13e.19e.28e"

include oe-alliance-settings.inc
