DESCRIPTION = "Henksat 19E,23E,28E"

SETTINGS_FILENAME = "e2_henksat_full_astra_1_2_3"

include henksat.inc
