DESCRIPTION = "tuncay SETTINGS for 19.2E Astra"

SETTINGS_FILENAME = "tuncay.astra"

include oe-alliance-settings.inc
