DESCRIPTION = "Gigablue 19e 16e 13e"

SETTINGS_FILENAME = "gigablue_19e_16e_13e"

include gigablue.inc
