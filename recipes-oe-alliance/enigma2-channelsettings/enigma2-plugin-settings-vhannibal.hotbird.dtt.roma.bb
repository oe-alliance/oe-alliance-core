DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Roma"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.roma"

include oe-alliance-settings.inc
