DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Italia"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.italia"

include oe-alliance-settings.inc
