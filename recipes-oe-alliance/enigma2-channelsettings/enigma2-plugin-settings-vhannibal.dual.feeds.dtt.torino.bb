DESCRIPTION = "Vhannibal E2 Settings File For Dual Feeds & DTT Torino"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.dual.feeds.dtt.torino"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "d4d074c02560276772b144d272f1d4fa"
SRC_URI[sha256sum] = "8e01844c2841045a581717672f544e962adb674fb1dbf8cc7519b798249cbb0b"
