DESCRIPTION = "Malimali Motor 42E to 30W Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.motor.42e.to.30w"

include oe-alliance-settings.inc
