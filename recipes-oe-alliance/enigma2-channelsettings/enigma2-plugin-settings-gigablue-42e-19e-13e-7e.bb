DESCRIPTION = "Gigablue 42e 19e 13e 7e"

SETTINGS_FILENAME = "gigablue_42e_19e_13e_7e"

include gigablue.inc
