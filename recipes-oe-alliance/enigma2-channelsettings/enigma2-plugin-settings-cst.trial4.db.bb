DESCRIPTION = "CST Trial4 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.trial4.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "65fd51fb9920d3bde904a3ddb69d6f52"
SRC_URI[sha256sum] = "995d6ee24ce8a1158cf41018dd06d4fcc990b0ff04b9f2fc61b16a4d8a4ceda6"
