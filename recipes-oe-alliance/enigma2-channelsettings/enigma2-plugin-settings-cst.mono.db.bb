DESCRIPTION = "CST Mono E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.mono.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "40b29b4b53a85162d9bbaa55eb5af64d"
SRC_URI[sha256sum] = "4a6a4d29149437b6c1274016fc4b1b84d173a0658a719263696398c4e2ec9eb1"
