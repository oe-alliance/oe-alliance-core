DESCRIPTION = "Swallow 19e, 13e E2 Settings File"

SETTINGS_FILENAME = "swallow.19e.13e"

include oe-alliance-settings.inc
