DESCRIPTION = "tuncay SETTINGS for combo kabel sat"

SETTINGS_FILENAME = "tuncay.combo.kabel.sat"

include oe-alliance-settings.inc
