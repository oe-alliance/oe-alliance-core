DESCRIPTION = "Gigablue kabel bw"

SETTINGS_FILENAME = "gigablue_kabel_bw"

include gigablue.inc
