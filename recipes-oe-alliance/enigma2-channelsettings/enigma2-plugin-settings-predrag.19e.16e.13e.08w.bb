DESCRIPTION = "Predr@d 19E, 16E, 13E, 08W"
PV = "20120223"

SETTINGS_FILENAME = "predrag.19e.16e.13e.08w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "54b9ba48e0d615f179eea2f3eb1e4523"
SRC_URI[sha256sum] = "29b83b6f07647b562c2e5a1ba59f8e1de3f78d09a4eabf4982930d8eaa63fdcc"
