DESCRIPTION = "Ciefp E2 Settings File For 19e, 16e, & 13e"

SETTINGS_FILENAME = "ciefp.fav.19e.16e.13e"

include oe-alliance-settings.inc
