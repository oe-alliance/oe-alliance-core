DESCRIPTION = "Vhannibal E2 Settings File For 9e, 13e, 16e & 19e"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.quad.9e.13e.16e.19e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "cd9f34bd1c9c02cf19b4dceab896d6da"
SRC_URI[sha256sum] = "f5638dd27aa589d495db498a960050842edf1dc59d0628a185683c377dca6c7f"
