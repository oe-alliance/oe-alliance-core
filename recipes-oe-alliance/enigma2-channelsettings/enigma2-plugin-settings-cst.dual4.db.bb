DESCRIPTION = "CST Dual4 E2 Settings File"

SETTINGS_FILENAME = "cst.dual4.db"

include oe-alliance-settings.inc
