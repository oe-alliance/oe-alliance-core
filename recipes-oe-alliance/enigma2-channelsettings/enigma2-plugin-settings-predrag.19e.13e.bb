DESCRIPTION = "Predr@d 19E, 13E"

SETTINGS_FILENAME = "predrag.19e.13e"

include oe-alliance-settings.inc
