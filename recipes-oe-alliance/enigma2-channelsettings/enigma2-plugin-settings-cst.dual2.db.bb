DESCRIPTION = "CST Dual2 E2 Settings File"

SETTINGS_FILENAME = "cst.dual2.db"

include oe-alliance-settings.inc
