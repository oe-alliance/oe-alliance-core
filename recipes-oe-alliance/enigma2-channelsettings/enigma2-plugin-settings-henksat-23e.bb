DESCRIPTION = "Henksat 23E"

SETTINGS_FILENAME = "e2_henksat_astra_3"

include henksat.inc
