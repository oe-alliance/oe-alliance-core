SUMMARY = "Gigablue wilhelmtel"

SETTINGS_FILENAME = "gigablue_wilhelmtel"

include gigablue.inc
