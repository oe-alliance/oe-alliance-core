DESCRIPTION = "Satvenus E2 Settings File For 19e.16e.13e"

SETTINGS_FILENAME = "satvenus.19e.16e.13e"

include oe-alliance-settings.inc
