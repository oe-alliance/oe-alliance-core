DESCRIPTION = "CST Motor DTT NA E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.motor.db.dtt.na"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "7ea3fc218e40aeb40aea66c466fc17dc"
SRC_URI[sha256sum] = "709fe845758155331b2c3f59f1438941f6b31289820e5c838958ed088d3f47ff"
