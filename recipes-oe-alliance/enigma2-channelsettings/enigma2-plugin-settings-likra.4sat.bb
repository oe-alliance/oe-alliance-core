DESCRIPTION = "Likra 4sat E2 Settings File"

SETTINGS_FILENAME = "likra.4sat"

include oe-alliance-settings.inc
