SATNAMES = "Motor"

require rytec-settings.inc

S = "${WORKDIR}/Rytec_E2_${SATNAMES}_${RYTECSETTINGS_SRCDATE}"

SRC_URI[md5sum] = "782b0e4eeab0ea15c70ca8cfe85a5f0a"
SRC_URI[sha256sum] = "1eb6b75848f544c75a3c848a3264bbacec59b63344ad3d4b19841cac56e791f5"
