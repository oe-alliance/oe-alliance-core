DESCRIPTION = "Henksat 13E,19E,23E,28E,42E,7E"

SETTINGS_FILENAME = "e2_henksat_astra_1_2_3_hb_42e_7e_thnx_to_yusuf"

include henksat.inc
