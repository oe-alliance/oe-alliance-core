DESCRIPTION = "CST Trial1 E2 Settings File"

SETTINGS_FILENAME = "cst.trial1.db"

include oe-alliance-settings.inc
