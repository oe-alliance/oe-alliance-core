DESCRIPTION = "Rickysnake E2 Settings File For 19e"

SETTINGS_FILENAME = "rickysnake.19e"

include oe-alliance-settings.inc
