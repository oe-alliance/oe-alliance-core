DESCRIPTION = "Predr@d 19e ,13e ,7e , 42e"

SETTINGS_FILENAME = "predrag.19e.13e.7e.42e"

include oe-alliance-settings.inc
