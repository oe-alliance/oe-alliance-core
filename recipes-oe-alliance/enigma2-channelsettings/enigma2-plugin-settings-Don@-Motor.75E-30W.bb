DESCRIPTION = "Don@ E2 Settings File For 75E-30W"

SETTINGS_FILENAME = "Don@-Motor.75E-30W"

include oe-alliance-settings.inc
