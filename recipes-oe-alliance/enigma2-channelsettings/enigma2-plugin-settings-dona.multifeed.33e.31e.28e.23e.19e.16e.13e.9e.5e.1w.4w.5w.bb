DESCRIPTION = "Don@ E2 Settings File For 33E+31E+28E+23E+19E+16E+13E+9E+5E+1W+4W+5W"

SETTINGS_FILENAME = "dona.multifeed.33e.31e.28e.23e.19e.16e.13e.9e.5e.1w.4w.5w"

include oe-alliance-settings.inc
