DESCRIPTION = "Henksat Ziggo regio 1111"

SETTINGS_FILENAME = "e2_henksat_ziggo-regio_1111"

include henksat.inc
