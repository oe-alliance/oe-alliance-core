DESCRIPTION = "CST Dual3 E2 Settings File"

SETTINGS_FILENAME = "cst.dual3.db"

include oe-alliance-settings.inc
