DESCRIPTION = "Gigablue kabeldeutschland"

SETTINGS_FILENAME = "gigablue_kabeldeutschland"

include gigablue.inc
