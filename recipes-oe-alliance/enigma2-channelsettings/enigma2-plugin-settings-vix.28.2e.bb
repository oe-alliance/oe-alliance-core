DESCRIPTION = "ViX E2 Settings File For 28.2 East"

SETTINGS_FILENAME = "vix.28.2e"

include oe-alliance-settings.inc
