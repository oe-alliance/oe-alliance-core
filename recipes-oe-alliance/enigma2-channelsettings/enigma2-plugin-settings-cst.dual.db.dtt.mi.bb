DESCRIPTION = "CST Dual DB DTT MI E2 Settings File"

SETTINGS_FILENAME = "cst.dual.db.dtt.mi"

include oe-alliance-settings.inc
