DESCRIPTION = "Don@ E2 Settings File For 28E+23E+19E+16E+13E+1W"

SETTINGS_FILENAME = "Don@-Multifeed.28E+23E+19E+16E+13E+1W"

include oe-alliance-settings.inc
