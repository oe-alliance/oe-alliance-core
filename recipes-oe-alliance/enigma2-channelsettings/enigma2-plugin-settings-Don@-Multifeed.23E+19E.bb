DESCRIPTION = "Don@ E2 Settings File For 23E+19E"

SETTINGS_FILENAME = "Don@-Multifeed.23E+19E"

include oe-alliance-settings.inc
