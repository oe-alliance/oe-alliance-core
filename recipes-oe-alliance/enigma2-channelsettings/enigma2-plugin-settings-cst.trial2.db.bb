DESCRIPTION = "CST Trial2 E2 Settings File"

SETTINGS_FILENAME = "cst.trial2.db"

include oe-alliance-settings.inc
