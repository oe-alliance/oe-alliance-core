DESCRIPTION = "Predr@d 13E, 19E"
PV = "20120223"

SETTINGS_FILENAME = "predrag.13e.19e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "d48defab1f890ffaefc9c369d6438109"
SRC_URI[sha256sum] = "746506d83ef980456c49a8ca882495732beaaf3027de225af52480b50e86e1b6"
