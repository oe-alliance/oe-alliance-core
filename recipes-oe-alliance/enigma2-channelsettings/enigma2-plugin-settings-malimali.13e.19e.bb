DESCRIPTION = "Malimali 13E, 19.2E Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.13e.19e"

include oe-alliance-settings.inc
