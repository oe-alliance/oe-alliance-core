DESCRIPTION = "Satvenus E2 Settings File For 9e.28e.23e.19e.16e.13e.9e.7e.5e.1w.4w.5w"

SETTINGS_FILENAME = "satvenus.39e.28e.23e.19e.16e.13e.9e.7e.5e.1w.4w.5w"

include oe-alliance-settings.inc
