DESCRIPTION = "Predr@d 19E"

SETTINGS_FILENAME = "predrag.19e"

include oe-alliance-settings.inc
