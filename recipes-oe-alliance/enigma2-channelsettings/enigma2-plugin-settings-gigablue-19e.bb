DESCRIPTION = "Gigablue 19E"

SETTINGS_FILENAME = "gigablue_19e"

include gigablue.inc
