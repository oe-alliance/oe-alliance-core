DESCRIPTION = "Ciefp E2 Settings File For 53e through to 30w"

SETTINGS_FILENAME = "ciefp.fav.53e.to.30w"

include oe-alliance-settings.inc
