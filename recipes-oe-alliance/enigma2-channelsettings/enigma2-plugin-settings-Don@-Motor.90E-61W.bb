DESCRIPTION = "Don@ E2 Settings File For 90E-61W"

SETTINGS_FILENAME = "Don@-Motor.90E-61W"

include oe-alliance-settings.inc
