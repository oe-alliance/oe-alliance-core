DESCRIPTION = "Don@ E2 Settings File For 39E+28E+23E+19E+16E+13E+9E+7E+5E+1W+4W+5W+8W+12W+15W"

SETTINGS_FILENAME = "dona.multifeed.39e.28e.23e.19e.16e.13e.9e.7e.5e.1w.4w.5w.8w.12w.15w"

include oe-alliance-settings.inc
