DESCRIPTION = "Matze 19E"

SETTINGS_FILENAME = "e2_matzesettings_19e"

include matze.inc
