DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Torino"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.torino"

include oe-alliance-settings.inc
