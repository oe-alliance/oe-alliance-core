DESCRIPTION = "Vhannibal Dual E2 Settings File"

SETTINGS_FILENAME = "vhannibal.dual"

include oe-alliance-settings.inc
