DESCRIPTION = "Don@ E2 Settings File For 42E-30W"

SETTINGS_FILENAME = "Don@-Motor.42E-30W"

include oe-alliance-settings.inc
