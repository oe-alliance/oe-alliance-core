DESCRIPTION = "Vhannibal E2 Settings File For Dual & DTT Italia"

SETTINGS_FILENAME = "vhannibal.dual.feeds.dtt.italia"

include oe-alliance-settings.inc
