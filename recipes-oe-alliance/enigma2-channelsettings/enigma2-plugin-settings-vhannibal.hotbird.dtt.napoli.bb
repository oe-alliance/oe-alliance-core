DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Napoli"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.napoli"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "94b4b0091db9d798d8a8c2377efc317e"
SRC_URI[sha256sum] = "b994c3dd38380bf584f8170b41ef9cab84081a3bbb41804b8f747abbd8b517de"
