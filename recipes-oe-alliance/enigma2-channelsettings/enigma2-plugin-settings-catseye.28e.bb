DESCRIPTION = "Catseye E2 Settings File For 28.2E"

SETTINGS_FILENAME = "catseye.28e"

include oe-alliance-settings.inc
