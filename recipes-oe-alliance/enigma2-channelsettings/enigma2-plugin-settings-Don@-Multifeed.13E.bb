DESCRIPTION = "Don@ E2 Settings File For 13E"

SETTINGS_FILENAME = "Don@-Multifeed.13E"

include oe-alliance-settings.inc
