DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Roma"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.roma"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "43c3aa1bfc0ac825a72559e049a74ebd"
SRC_URI[sha256sum] = "470f7e461b29bd2381d3e90e86afaeb3dd567b32c200dc0dfbad5214b7136822"
