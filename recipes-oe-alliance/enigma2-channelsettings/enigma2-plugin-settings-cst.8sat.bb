DESCRIPTION = "CST 8 Sat E2 Settings File"

SETTINGS_FILENAME = "cst.8sat"

include oe-alliance-settings.inc
