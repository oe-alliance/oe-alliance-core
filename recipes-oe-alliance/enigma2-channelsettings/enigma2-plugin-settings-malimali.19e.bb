DESCRIPTION = "Malimali 19.2E Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.19e"

include oe-alliance-settings.inc
