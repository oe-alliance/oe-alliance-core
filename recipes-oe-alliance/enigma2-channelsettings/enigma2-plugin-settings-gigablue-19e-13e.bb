DESCRIPTION = "Gigablue 19E 13e"

SETTINGS_FILENAME = "gigablue_19e_13e"

include gigablue.inc
