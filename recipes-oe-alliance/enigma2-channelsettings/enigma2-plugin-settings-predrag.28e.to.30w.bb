DESCRIPTION = "Predr@d 28E to 30W"
PV = "20120223"

SETTINGS_FILENAME = "predrag.28e.to.30w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "05063fcebbc47180b7bd52bdafce1ed1"
SRC_URI[sha256sum] = "29e56d04d2adfada1a0932170b6ee22d31bde4f10826a7339164a838cbe54316"
