DESCRIPTION = "Rickysnake E2 Settings File For 13e, 19e"

SETTINGS_FILENAME = "rickysnake.13e.19e"

include oe-alliance-settings.inc
