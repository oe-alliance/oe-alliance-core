DESCRIPTION = "Don@ E2 Settings File For 23E+19E"

SETTINGS_FILENAME = "dona.multifeed.23e.19e"

include oe-alliance-settings.inc
