DESCRIPTION = "CST Dual1 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.dual1.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "2249b00c262e19f7a267d24fdf0c113c"
SRC_URI[sha256sum] = "cbae48b39ef8a097eaf9d31f78f64f7ed00845980b31c18a2ee4c8d35b8e85fa"
