DESCRIPTION = "Don@ E2 Settings File For 19E+16E+13E+5E+1W+4W+5W"

SETTINGS_FILENAME = "Don@-Multifeed.19E+16E+13E+5E+1W+4W+5W"

include oe-alliance-settings.inc
