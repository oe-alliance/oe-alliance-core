DESCRIPTION = "Predr@d Motor 42E to 30W"
PV = "20120223"

SETTINGS_FILENAME = "predrag.motor.42e.to.30w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "80382509907e9095b1763d18323e9f78"
SRC_URI[sha256sum] = "da8c83059855c938aa046c9331ac4628113edd077d1ad34dc0e83a0eea8b0db6"
