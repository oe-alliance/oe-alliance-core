DESCRIPTION = "Predr@d 13E"

SETTINGS_FILENAME = "predrag.13e"

include oe-alliance-settings.inc
