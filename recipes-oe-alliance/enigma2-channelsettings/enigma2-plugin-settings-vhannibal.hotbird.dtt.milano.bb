DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Milano"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.milano"

include oe-alliance-settings.inc
