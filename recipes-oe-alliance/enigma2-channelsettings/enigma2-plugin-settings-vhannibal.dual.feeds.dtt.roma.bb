DESCRIPTION = "Vhannibal E2 Settings File For Dual Feeds & DTT Roma"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.dual.feeds.dtt.roma"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "5f35aba32e0befebb2fc967897fa1462"
SRC_URI[sha256sum] = "6ae802b461c9c43aa85856c788efe44440a7be2162e09f8825f35a7b286b0648"
