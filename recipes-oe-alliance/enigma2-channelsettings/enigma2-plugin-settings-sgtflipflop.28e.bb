DESCRIPTION = "Sgtflipflop E2 Settings File For 28e"

SETTINGS_FILENAME = "sgtflipflop.28e"

include oe-alliance-settings.inc
