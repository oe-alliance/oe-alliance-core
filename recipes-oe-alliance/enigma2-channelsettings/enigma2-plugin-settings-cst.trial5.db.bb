DESCRIPTION = "CST Trial5 E2 Settings File"

SETTINGS_FILENAME = "cst.trial5.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "89d2a2e08994b8466837900c5029f2f2"
SRC_URI[sha256sum] = "91fd4400f21edd8284eae69a3470bdb8030cb6effc9efd8591984aaac2ef6eaf"
