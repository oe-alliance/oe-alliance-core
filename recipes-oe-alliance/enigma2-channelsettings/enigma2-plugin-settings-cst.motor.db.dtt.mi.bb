DESCRIPTION = "CST Motor DTT MI E2 Settings File"

SETTINGS_FILENAME = "cst.motor.db.dtt.mi"

include oe-alliance-settings.inc
