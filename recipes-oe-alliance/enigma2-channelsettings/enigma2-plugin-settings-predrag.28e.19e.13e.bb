DESCRIPTION = "Predr@d 28e ,19e ,13e"

SETTINGS_FILENAME = "predrag.28e.19e.13e"

include oe-alliance-settings.inc
