DESCRIPTION = "Don@ E2 Settings File For 19E+13E"

SETTINGS_FILENAME = "dona.multifeed.19e.13e"

include oe-alliance-settings.inc
