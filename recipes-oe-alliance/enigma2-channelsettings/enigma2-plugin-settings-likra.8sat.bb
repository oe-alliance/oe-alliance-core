DESCRIPTION = "Likra 8sat E2 Settings File"

SETTINGS_FILENAME = "likra.8sat"

include oe-alliance-settings.inc
