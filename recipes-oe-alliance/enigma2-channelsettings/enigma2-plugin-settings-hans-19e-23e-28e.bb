DESCRIPTION = "Hans 19E,23E,28E"

SETTINGS_FILENAME = "e2_hanssettings_19e_23e_28e"

include hans.inc
