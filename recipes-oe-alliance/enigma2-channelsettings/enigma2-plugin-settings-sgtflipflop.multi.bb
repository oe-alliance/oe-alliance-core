DESCRIPTION = "Sgtflipflop E2 Settings File For Multiple Sats"

SETTINGS_FILENAME = "sgtflipflop.multi"

include oe-alliance-settings.inc
