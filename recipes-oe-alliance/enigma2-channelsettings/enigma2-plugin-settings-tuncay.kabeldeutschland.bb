DESCRIPTION = "tuncay SETTINGS for kabeldeutschland"

SETTINGS_FILENAME = "tuncay.kabeldeutschland"

include oe-alliance-settings.inc
