DESCRIPTION = "CST Dual DB DTT NA E2 Settings File"

SETTINGS_FILENAME = "cst.dual.db.dtt.na"

include oe-alliance-settings.inc
