DESCRIPTION = "Ocram Icesat 28e, 23e, 19e, 13e E2 Settings File"

SETTINGS_FILENAME = "icesat.28e.23e.19e.13e"

include oe-alliance-settings.inc
