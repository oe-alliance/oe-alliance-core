DESCRIPTION = "Gigablue 19e 13e 5e 75e"

SETTINGS_FILENAME = "gigablue_19e_13e_5e_75e"

include gigablue.inc
