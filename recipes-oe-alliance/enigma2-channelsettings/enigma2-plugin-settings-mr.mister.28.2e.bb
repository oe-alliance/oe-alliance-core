DESCRIPTION = "Mr Mister E2 Settings File For 28.2 East"

SETTINGS_FILENAME = "mr.mister.28.2e"

include oe-alliance-settings.inc
