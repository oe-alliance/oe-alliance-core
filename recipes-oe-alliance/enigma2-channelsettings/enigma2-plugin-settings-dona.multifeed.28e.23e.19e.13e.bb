DESCRIPTION = "Don@ E2 Settings File For 28E+23E+19E+13E"

SETTINGS_FILENAME = "dona.multifeed.28e.23e.19e.13e"

include oe-alliance-settings.inc
