DESCRIPTION = "CST Four E2 Settings File"

SETTINGS_FILENAME = "cst.four.db"

include oe-alliance-settings.inc
