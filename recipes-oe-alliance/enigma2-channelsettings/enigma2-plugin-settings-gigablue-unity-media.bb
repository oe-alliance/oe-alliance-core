DESCRIPTION = "Gigablue unity_media"

SETTINGS_FILENAME = "gigablue_unity_media"

include gigablue.inc
