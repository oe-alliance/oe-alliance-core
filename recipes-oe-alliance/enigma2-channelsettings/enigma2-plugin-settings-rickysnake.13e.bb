DESCRIPTION = "Rickysnake E2 Settings File For 13e"

SETTINGS_FILENAME = "rickysnake.13e"

include oe-alliance-settings.inc
