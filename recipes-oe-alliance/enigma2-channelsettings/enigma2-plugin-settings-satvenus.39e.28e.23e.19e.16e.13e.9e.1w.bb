DESCRIPTION = "Satvenus E2 Settings File For 39e.28e.23e.19e.16e.13e.9e.1w"

SETTINGS_FILENAME = "satvenus.39e.28e.23e.19e.16e.13e.9e.1w"

include oe-alliance-settings.inc
