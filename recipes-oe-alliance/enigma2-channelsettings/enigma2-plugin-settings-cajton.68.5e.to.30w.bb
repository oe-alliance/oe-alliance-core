DESCRIPTION = "Cajton E2 Settings File For 68.5e through to 30w"
PV = "20120225"

SETTINGS_FILENAME = "cajton.68.5e.to.30w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "b4cc77e0e231db67c70c8f4960fde520"
SRC_URI[sha256sum] = "b384f5ef93bd0e1f08a1a475b8b68cf7ddf7379ce270596ba943cdae83698006"
