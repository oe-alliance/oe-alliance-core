DESCRIPTION = "B16MCC E2 Settings File For 28e"

SETTINGS_FILENAME = "b16mcc.28e"

include oe-alliance-settings.inc
