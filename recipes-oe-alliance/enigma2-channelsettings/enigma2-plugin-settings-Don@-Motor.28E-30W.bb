DESCRIPTION = "Don@ E2 Settings File For 28E-30W"

SETTINGS_FILENAME = "Don@-Motor.28E-30W"

include oe-alliance-settings.inc
