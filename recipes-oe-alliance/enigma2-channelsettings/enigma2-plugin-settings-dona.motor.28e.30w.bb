DESCRIPTION = "Don@ E2 Settings File For 28E-30W"

SETTINGS_FILENAME = "dona.motor.28e.30w"

include oe-alliance-settings.inc
