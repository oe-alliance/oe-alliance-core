DESCRIPTION = "Don@ E2 Settings File For 75E-30W"

SETTINGS_FILENAME = "dona.motor.75e.30w"

include oe-alliance-settings.inc
