DESCRIPTION = "ureyesonly SETTINGS for 28.2E"

SETTINGS_FILENAME = "ureyesonly.28.2e"

include oe-alliance-settings.inc
