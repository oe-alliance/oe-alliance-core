DESCRIPTION = "CST Five.1 E2 Settings File"

SETTINGS_FILENAME = "cst.five.1.db"

include oe-alliance-settings.inc
