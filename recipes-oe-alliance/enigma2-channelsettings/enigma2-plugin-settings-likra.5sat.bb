DESCRIPTION = "Likra 5sat E2 Settings File"
PV = "20111210"

SETTINGS_FILENAME = "likra.5sat"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "8057556d54d130584e3fa64d3f9ebffa"
SRC_URI[sha256sum] = "74d5f8adaff1d822307e4f2d77526ba522ab5fdf199475183d4588cd84adb7f1"
