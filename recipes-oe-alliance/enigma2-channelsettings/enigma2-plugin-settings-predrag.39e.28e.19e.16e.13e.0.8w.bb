DESCRIPTION = "Predr@d  39e,28e,19e,16e,13e,0.8w"

SETTINGS_FILENAME = "predrag.39e.28e.19e.16e.13e.0.8w"

include oe-alliance-settings.inc
