DESCRIPTION = "Ciefp E2 Settings File For 39e, 28e, 26e, 23e, 19e, 16e, 13e 7e, 5e, & 0.8w"

SETTINGS_FILENAME = "ciefp.fav.39e.28e.26e.23e.19e.16e.13e.7e.5e.08w"

include oe-alliance-settings.inc
