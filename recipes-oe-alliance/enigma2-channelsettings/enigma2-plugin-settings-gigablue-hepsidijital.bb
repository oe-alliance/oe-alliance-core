DESCRIPTION = "hepsidijital_42e_19e_13e_7e"

SETTINGS_FILENAME = "hepsidijital_42e_19e_13e_7e"

include gigablue.inc
