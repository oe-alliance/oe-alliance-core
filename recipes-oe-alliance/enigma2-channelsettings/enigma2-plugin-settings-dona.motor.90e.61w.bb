DESCRIPTION = "Don@ E2 Settings File For 90E-61W"

SETTINGS_FILENAME = "dona.motor.90e.61w"

include oe-alliance-settings.inc
