DESCRIPTION = "Don@ E2 Settings File For 42E-30W"

SETTINGS_FILENAME = "dona.motor.42e.30w"

include oe-alliance-settings.inc
