DESCRIPTION = "Satvenus E2 Settings File For 19e.16e.13e.1w"

SETTINGS_FILENAME = "satvenus.19e.16e.13e.1w"

include oe-alliance-settings.inc
