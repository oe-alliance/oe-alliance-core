DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Forli"
PV = "20120306"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.forli"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "30f8beff898115330ac993cd38f025a0"
SRC_URI[sha256sum] = "2aaa150ce7a8ed5ae2a257fc35570caa0174854604a902e76a474c3abc85637f"
