DESCRIPTION = "CST Mono DB DTT NA E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.mono.db.dtt.na"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "fa1135153010b0139efa4884d39295c3"
SRC_URI[sha256sum] = "5dfb39eb70d76c7b01a566beb782ddb5c9f58663615a983f0e2f2ccc5e58926e"
