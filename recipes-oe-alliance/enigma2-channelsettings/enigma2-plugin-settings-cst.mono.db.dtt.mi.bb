DESCRIPTION = "CST Mono DB DTT MI E2 Settings File"

SETTINGS_FILENAME = "cst.mono.db.dtt.mi"

include oe-alliance-settings.inc
