DESCRIPTION = "Don@ E2 Settings File For 28E+19E+16E+13E"

SETTINGS_FILENAME = "Don@-Multifeed.28E+19E+16E+13E"

include oe-alliance-settings.inc
