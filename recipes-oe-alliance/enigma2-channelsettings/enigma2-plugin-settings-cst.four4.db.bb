DESCRIPTION = "CST Four4 E2 Settings File"

SETTINGS_FILENAME = "cst.four4.db"

include oe-alliance-settings.inc
