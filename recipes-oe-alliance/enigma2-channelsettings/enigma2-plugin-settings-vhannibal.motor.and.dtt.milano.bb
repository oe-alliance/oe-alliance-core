DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Milano"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.milano"

include oe-alliance-settings.inc
