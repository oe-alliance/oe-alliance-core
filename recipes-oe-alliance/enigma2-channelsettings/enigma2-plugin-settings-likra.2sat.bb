DESCRIPTION = "Likra 2sat E2 Settings File"

SETTINGS_FILENAME = "likra.2sat"

include oe-alliance-settings.inc
