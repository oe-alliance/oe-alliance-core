DESCRIPTION = "Catseye E2 Settings File For 75E - 58W"

SETTINGS_FILENAME = "catseye.75e.to.58w"

include oe-alliance-settings.inc
