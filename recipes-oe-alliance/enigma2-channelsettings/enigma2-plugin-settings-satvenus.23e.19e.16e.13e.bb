DESCRIPTION = "Satvenus E2 Settings File For 23e.19e.16e.13e"

SETTINGS_FILENAME = "satvenus.23e.19e.16e.13e"

include oe-alliance-settings.inc
