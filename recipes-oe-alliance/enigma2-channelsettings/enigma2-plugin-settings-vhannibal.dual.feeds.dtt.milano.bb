DESCRIPTION = "Vhannibal E2 Settings File For Dual Feeds & DTT milano"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.dual.feeds.dtt.milano"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "0b8fd1f054a1c22628f7c75324edefab"
SRC_URI[sha256sum] = "0e43e46aa76ccc98edba0479aaaacdc81a9cc3ee5c201e99eefa6ec7c63b4b95"
