DESCRIPTION = "Don@ E2 Settings File For 19e,16e,13e,5e,1w,4w,5w"

SETTINGS_FILENAME = "dona.multifeed.19e.16e.13e.5e.1w.4w.5w"

include oe-alliance-settings.inc
