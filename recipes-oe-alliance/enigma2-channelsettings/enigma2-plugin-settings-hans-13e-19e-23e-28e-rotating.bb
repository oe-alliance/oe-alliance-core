DESCRIPTION = "Hans 13E,19E,23E,28E and rotating"

SETTINGS_FILENAME = "e2_hanssettings_13e_19e_23e_28e_AND_rotating"

include hans.inc
