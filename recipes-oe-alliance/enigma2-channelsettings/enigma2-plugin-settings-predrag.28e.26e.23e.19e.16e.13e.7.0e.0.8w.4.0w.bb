DESCRIPTION = "Predr@d 28e,26e,23e,19e,16e,13e,7.0e,0.8w,4.0w"

SETTINGS_FILENAME = "predrag.28e.26e.23e.19e.16e.13e.7.0e.0.8w.4.0w"

include oe-alliance-settings.inc
