DESCRIPTION = "Predr@d  42e, 19e, 13e, 7e"

SETTINGS_FILENAME = "predrag.42e.19e.13e.7e"

include oe-alliance-settings.inc
