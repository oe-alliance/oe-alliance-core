DESCRIPTION = "Catseye E2 Settings File For 13E 19.2E 16E 23.5E"

SETTINGS_FILENAME = "catseye.13e.19e.16e.23e"

include oe-alliance-settings.inc
