DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Torino"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.torino"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "d56f5456b0d72fab89b44d6d897e9314"
SRC_URI[sha256sum] = "bc6ca57b65ba05170946c4abc2620f8d5410f2266aeb1217c0c2b38d2bdefacf"
