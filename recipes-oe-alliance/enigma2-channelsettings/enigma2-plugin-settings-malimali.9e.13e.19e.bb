DESCRIPTION = "Malimali 9E, 13E, 19.2E Sat E2 Settings File"

SETTINGS_FILENAME = "malimali.9e.13e.19e"

include oe-alliance-settings.inc
