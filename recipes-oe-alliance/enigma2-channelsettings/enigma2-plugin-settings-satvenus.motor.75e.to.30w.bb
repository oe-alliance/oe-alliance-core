DESCRIPTION = "Satvenus E2 Settings File For Motor 75E to 30W"

SETTINGS_FILENAME = "satvenus.motor.75e.to.30w"

include oe-alliance-settings.inc
