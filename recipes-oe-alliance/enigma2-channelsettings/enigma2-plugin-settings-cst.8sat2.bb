DESCRIPTION = "CST 8 Sat2 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.8sat2"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "f85c59254df954855143c83dc981e987"
SRC_URI[sha256sum] = "1c9e694c74c502ad79af13e6c991c48fc2fba3de43def4c88f8742f72f426d3e"
