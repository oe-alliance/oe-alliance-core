DESCRIPTION = "CST Five.2 E2 Settings File"

SETTINGS_FILENAME = "cst.five2.db"

include oe-alliance-settings.inc
