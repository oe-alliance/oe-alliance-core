DESCRIPTION = "Catseye E2 Settings File For 5E 1W"

SETTINGS_FILENAME = "catseye.5e.1w"

include oe-alliance-settings.inc
