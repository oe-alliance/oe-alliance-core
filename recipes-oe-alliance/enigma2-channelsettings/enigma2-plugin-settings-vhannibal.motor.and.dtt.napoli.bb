DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Napoli"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.napoli"

include oe-alliance-settings.inc
