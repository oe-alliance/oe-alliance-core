DESCRIPTION = "Satvenus E2 Settings File For 28e.23e.19e.13e"

SETTINGS_FILENAME = "satvenus.28e.23e.19e.13e"

include oe-alliance-settings.inc
