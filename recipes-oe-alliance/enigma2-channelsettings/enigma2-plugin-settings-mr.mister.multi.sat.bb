DESCRIPTION = "Mr Mister E2 Settings File For Multi Sat"
PV = "20120109"

SETTINGS_FILENAME = "mr.mister.multi.sat"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "312488e932a68513db6ad1ec77b630a1"
SRC_URI[sha256sum] = "b22363d964f403f10918ab53d2d9689ee0011dac7190df123658e8e7ac57d630"
