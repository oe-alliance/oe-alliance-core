DESCRIPTION = "Don@ E2 Settings File For 19E"

SETTINGS_FILENAME = "Don@-Multifeed.19E"

include oe-alliance-settings.inc
