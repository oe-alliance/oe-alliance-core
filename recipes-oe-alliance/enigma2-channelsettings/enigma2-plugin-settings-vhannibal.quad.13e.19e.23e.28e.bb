DESCRIPTION = "Vhannibal E2 Settings File For 13e,19e, 23e & 28e"

SETTINGS_FILENAME = "vhannibal.quad.13e.19e.23e.28e"

include oe-alliance-settings.inc
