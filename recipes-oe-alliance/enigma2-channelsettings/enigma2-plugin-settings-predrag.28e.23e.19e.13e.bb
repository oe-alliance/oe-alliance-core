DESCRIPTION = "Predr@d 28.2E, 23.5E, 19E, 13E"

SETTINGS_FILENAME = "predrag.28e.23e.19e.13e"

include oe-alliance-settings.inc
