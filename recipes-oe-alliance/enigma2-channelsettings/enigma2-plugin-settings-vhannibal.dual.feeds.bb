DESCRIPTION = "Vhannibal Dual Feeds E2 Settings File"

SETTINGS_FILENAME = "vhannibal.dual.feeds"

include oe-alliance-settings.inc
