DESCRIPTION = "Don@ E2 Settings File For 33E+31E+28E+23E+19E+16E+13E+9E+5E+1W+4W+5W"

SETTINGS_FILENAME = "Don@-Multifeed.33E+31E+28E+23E+19E+16E+13E+9E+5E+1W+4W+5W"

include oe-alliance-settings.inc
