DESCRIPTION = "CST Trial3 E2 Settings File"

SETTINGS_FILENAME = "cst.trial3.db"

include oe-alliance-settings.inc
