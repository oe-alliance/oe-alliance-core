DESCRIPTION = "CST Four3 E2 Settings File"

SETTINGS_FILENAME = "cst.four3.db"

include oe-alliance-settings.inc
