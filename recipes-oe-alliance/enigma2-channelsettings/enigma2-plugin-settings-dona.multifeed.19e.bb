DESCRIPTION = "Don@ E2 Settings File For 19E"

SETTINGS_FILENAME = "dona.multifeed.19e"

include oe-alliance-settings.inc
