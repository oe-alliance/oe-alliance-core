DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Italia"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.italia"

include oe-alliance-settings.inc
