DESCRIPTION = "Vhannibal E2 Settings File Quad Nordic"

SETTINGS_FILENAME = "vhannibal.quad.nordic"

include oe-alliance-settings.inc
