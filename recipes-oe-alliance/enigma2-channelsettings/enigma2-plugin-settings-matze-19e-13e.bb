DESCRIPTION = "Matze 19E,13E"

SETTINGS_FILENAME = "e2_matzesettings_19e_13e"

include matze.inc
