DESCRIPTION = "Henksat Rotating 45E-45W"

SETTINGS_FILENAME = "e2_henksat_rotating_45e_45w"

include henksat.inc
