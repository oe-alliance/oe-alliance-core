DESCRIPTION = "tuncay SETTINGS for 19e 13e"

SETTINGS_FILENAME = "tuncay.19e.13e.astra.hortbird"

include oe-alliance-settings.inc
