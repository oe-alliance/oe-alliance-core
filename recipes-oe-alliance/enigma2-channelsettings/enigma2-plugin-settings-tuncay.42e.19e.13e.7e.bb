DESCRIPTION = "tuncay SETTINGS for 42e 19e 13e 7e"

SETTINGS_FILENAME = "tuncay.42e.19e.13e.7e"

include oe-alliance-settings.inc
