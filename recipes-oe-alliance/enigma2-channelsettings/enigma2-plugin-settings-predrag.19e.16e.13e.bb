DESCRIPTION = "Predr@d 19E, 16E, 19E"

SETTINGS_FILENAME = "predrag.19e.16e.13e"

include oe-alliance-settings.inc
