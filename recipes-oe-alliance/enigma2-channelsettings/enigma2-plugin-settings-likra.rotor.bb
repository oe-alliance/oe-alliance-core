DESCRIPTION = "Likra Rotor E2 Settings File"
PV = "20111210"

SETTINGS_FILENAME = "likra.rotor"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "4f3d91873c99bae6286491fc45e02a2a"
SRC_URI[sha256sum] = "7e3991d3c389f9b49028193d889dacca32205cb027db3ca57937369b9eb022b5"
