DESCRIPTION = "Likra 3sat E2 Settings File"
PV = "20111210"

SETTINGS_FILENAME = "likra.3sat"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "727a2ede6f8eca722b7e47a5b161aeeb"
SRC_URI[sha256sum] = "e5aca79c11fb2298524c616f5abd4c4b8d828ead53658cbada28c492b9471481"
