PRINC = "1"

SRC_URI = "git://git.profusion.mobi/users/lfelipe/kmod.git \
           file://0001-man-disable-man-page-generation-because-we-don-t-hav.patch \
"

