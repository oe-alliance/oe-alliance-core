require linux-libc-headers.inc

PR = "2"

SRC_URI[md5sum] = "fad4c270fe68fcc8d15258c868bc2733"
SRC_URI[sha256sum] = "df8c6071cbdd6a709aebb8a272dca60791edb379103597670609ef90e148d8bb"
