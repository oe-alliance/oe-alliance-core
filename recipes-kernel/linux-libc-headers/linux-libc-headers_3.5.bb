PRINC = "1"

require linux-libc-headers.inc

SRC_URI[md5sum] = "3ed693d5dee4f4aa05e15d3c19f6cf01"
SRC_URI[sha256sum] = "6ab82beb8cbb895b7523daed7ec3ec5850cf460b96788056f1ef5135c852fd23"
