require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

PR = "0"

SRC_URI[md5sum] = "3f9f8d800c017ede266744c6692df6c9"
SRC_URI[sha256sum] = "515ee5fcd979ba7e151ce9a168140281d251e663a15bc0cbbcd09aebd8677262"
