PRINC = "1"

require linux-libc-headers.inc

SRC_URI[md5sum] = "98a6cdd7d082b7ea72df9c89842bac74"
SRC_URI[sha256sum] = "8fd669b4e48181b8d44644a45bf421a84bb8d5ec273ef36349796443e442f333"
