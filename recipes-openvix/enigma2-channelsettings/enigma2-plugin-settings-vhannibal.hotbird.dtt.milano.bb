DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Milano"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.milano"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "9fbfefb6a5e6ebaa235719cb4deea70f"
SRC_URI[sha256sum] = "2bd33a9e18cc7554687befd5cc9d093a12ae15b5d0de0d84adf44fb3ad95c971"
