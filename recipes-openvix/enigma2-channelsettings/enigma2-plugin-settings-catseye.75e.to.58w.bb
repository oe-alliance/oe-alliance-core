DESCRIPTION = "Catseye E2 Settings File For 75E - 58W"
PV = "20120222"

SETTINGS_FILENAME = "catseye.75e.to.58w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "141f9fc780754730c062e477f03f00c1"
SRC_URI[sha256sum] = "750a531f3e7d5fb4c2f5279fa272b9d83fed9f949fe4e8841db3c8cee84e572f"
