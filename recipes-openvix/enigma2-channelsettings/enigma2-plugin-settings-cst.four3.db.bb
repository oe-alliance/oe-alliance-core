DESCRIPTION = "CST Four3 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.four3.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "e9aff7b5211eaf1f1c4b9e60d79a3909"
SRC_URI[sha256sum] = "c877e1dba0d8cefa7aacbdde537c1ade9f5d3a6cc1f345d8d2633ad6f58c10ba"
