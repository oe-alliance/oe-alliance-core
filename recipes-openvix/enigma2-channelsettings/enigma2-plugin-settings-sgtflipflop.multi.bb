DESCRIPTION = "Sgtflipflop E2 Settings File For Multiple Sats"
PV = "20120307"

SETTINGS_FILENAME = "sgtflipflop.multi"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "89e1d3c98dc302101ec7aff4030716be"
SRC_URI[sha256sum] = "dff12b78b29fc1843e95b6b45ee571a828a9d4b736811eb2b586c1f859f20f89"
