DESCRIPTION = "CST Motor DTT MI E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.motor.db.dtt.mi"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "71f19d935a70ddc0d7339e824e91c613"
SRC_URI[sha256sum] = "9eee2a0a9c5c910030eea727a2f7d1bce1d7363243e6b93070534627733c6365"
