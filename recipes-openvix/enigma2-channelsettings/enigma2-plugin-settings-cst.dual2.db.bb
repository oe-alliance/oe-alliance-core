DESCRIPTION = "CST Dual2 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.dual2.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "6f7dd4cd834a564a06f9e75209b461fa"
SRC_URI[sha256sum] = "3e1b0f350b8c9395ec60d4f7f8f0938b59ad7f2261353798a7dc3d037eb5a071"
