DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Italia"
PV = "20111208"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.italia"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "002182f36a11b8d46f5f63eb376aa1a5"
SRC_URI[sha256sum] = "cec84c2d4c6fc2295e7da0d22380d1d64d8939382bef67a2823ee60ebcb09988"
