DESCRIPTION = "Likra 4sat E2 Settings File"
PV = "20111210"

SETTINGS_FILENAME = "likra.4sat"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "aaac457002802004eb13a3c49e14887c"
SRC_URI[sha256sum] = "b416e4a721eb2376fee899e8d88a84142402539f550d1266e73062277e3df38b"
