DESCRIPTION = "CST Dual3 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.dual3.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "5b3afccbb6c3bdbba7571132b80bb461"
SRC_URI[sha256sum] = "5ee37a82219dd9e301343369f46ec783c1b5c16b4e50e3fcaaf2c226d5fcd53d"
