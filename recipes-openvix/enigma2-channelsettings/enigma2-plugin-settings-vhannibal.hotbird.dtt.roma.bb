DESCRIPTION = "Vhannibal E2 Settings File For HotBird & DTT Roma"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.hotbird.dtt.roma"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "07515f2fdc08149ad0515085ebe96d7c"
SRC_URI[sha256sum] = "78413c4adba4d5c90928a076ad6f94ddd02af52b0daa5a195fc1141323576a95"
