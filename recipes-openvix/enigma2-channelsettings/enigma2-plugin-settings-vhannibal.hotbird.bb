DESCRIPTION = "Vhannibal E2 Settings File For HotBird"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.hotbird"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "bdf1617166abbc741cf925a6c6ed2d45"
SRC_URI[sha256sum] = "d10883d4162dcd4b36de14705273a51960ac9421873429a890403bf6c5dfb47d"
