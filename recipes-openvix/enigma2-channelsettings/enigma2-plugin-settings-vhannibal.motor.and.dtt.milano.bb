DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Milano"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.milano"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "dcb4f964e92e6bb4c779714002ad571b"
SRC_URI[sha256sum] = "d1127ba85cb2a9a5383a68b6b91b56383fc31258e0f94ce93bc9fa3e023a36ab"
