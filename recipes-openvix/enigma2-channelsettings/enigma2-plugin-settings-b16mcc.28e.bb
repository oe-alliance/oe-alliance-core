DESCRIPTION = "B16MCC E2 Settings File For 28e"
PV = "${SRCDATE}"

SETTINGS_FILENAME = "b16mcc.28e"

include bouquets-e2settings.inc
