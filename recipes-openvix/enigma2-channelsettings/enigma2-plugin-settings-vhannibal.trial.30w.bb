DESCRIPTION = "Vhannibal E2 Settings File Trial 30w"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.trial.30w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "629d7f1682f05e0d74a93b6a189e19b5"
SRC_URI[sha256sum] = "3260681975c080028284bd4ca76870fbe53f406e228da50912f6578222d2a286"
