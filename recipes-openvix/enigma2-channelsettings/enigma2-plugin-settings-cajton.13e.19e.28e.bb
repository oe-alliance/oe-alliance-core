DESCRIPTION = "Cajton E2 Settings File For 13e, 19e & 28e"
PV = "20120225"

SETTINGS_FILENAME = "cajton.13e.19e.28e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "8339aaf82f77db8da1eb0adc7ecc6341"
SRC_URI[sha256sum] = "2d8e8ea213c8c98ff20ae27c18bda9224037fba0b4008208847e88e45e7b2470"
