DESCRIPTION = "Ciefp E2 Settings File For 19e, 16e, 13e & 08w"
PV = "20120302"

SETTINGS_FILENAME = "ciefp.fav.19e.16e.13e.08w"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "cee12764bc152d75ed8cc953e3a51086"
SRC_URI[sha256sum] = "85ebf96fde27840539a6e18f0d1f6bb0787d544713737d648f87e68f0950731d"
