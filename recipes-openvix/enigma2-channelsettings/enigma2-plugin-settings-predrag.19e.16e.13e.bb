DESCRIPTION = "Predr@d 19E, 16E, 19E"
PV = "20120223"

SETTINGS_FILENAME = "predrag.19e.16e.13e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "6592ec3f01303a57c197b70d2fe491a9"
SRC_URI[sha256sum] = "f921b60066d80d97802d96744b5789a65791ac2937b6513ad44d4d4ee8465944"
