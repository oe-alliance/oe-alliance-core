DESCRIPTION = "Vhannibal E2 Settings File For 13e,19e, 23e & 28e"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.quad.13e.19e.23e.28e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "fecbe76193d100a1bafd8c12a15ebd66"
SRC_URI[sha256sum] = "60fdf1abc48865faf58c511ebf5f9f860a02b7e106db306ac5fd1a8edf295484"
