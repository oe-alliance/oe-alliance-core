DESCRIPTION = "Vhannibal Dual Feeds E2 Settings File"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.dual.feeds"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "740293b99c10153dac735acc3159a291"
SRC_URI[sha256sum] = "e81d2eab5c4fe0e8c432716299c26a5b59f381b4abcfa1d4d0b49fb21e332925"
