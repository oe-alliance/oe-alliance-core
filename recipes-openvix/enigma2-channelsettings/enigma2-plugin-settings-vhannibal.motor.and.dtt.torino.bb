DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Torino"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.torino"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "0b860bf36d8088bbd8e46c2ac8abba24"
SRC_URI[sha256sum] = "6fc625cef4cc3b6040c0491920247f3cf82785405aa6939a3776e540283936de"
