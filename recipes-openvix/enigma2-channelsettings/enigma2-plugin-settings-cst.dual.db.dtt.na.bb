DESCRIPTION = "CST Dual DB DTT NA E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.dual.db.dtt.na"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "ecc7baf9c80f6d6b08b908d5d622f4a2"
SRC_URI[sha256sum] = "78948edf41e877be2f7d013597d89d982a92911f3cf14b3ac07501399462dcc5"
