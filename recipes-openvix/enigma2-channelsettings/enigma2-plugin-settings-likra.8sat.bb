DESCRIPTION = "Likra 8sat E2 Settings File"
PV = "20111210"

SETTINGS_FILENAME = "likra.8sat"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "9b52462d2f93c2b713f1b1068ba0e882"
SRC_URI[sha256sum] = "d073c2fdf46c3ec5c213c08c8f1a27ecdf7cbbc799be8c7fc6dd2f5465cff46f"
