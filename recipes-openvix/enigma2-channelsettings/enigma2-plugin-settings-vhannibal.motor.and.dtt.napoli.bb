DESCRIPTION = "Vhannibal E2 Settings File For Motor & DTT Napoli"
PV = "20120220"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.napoli"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "536213c016b7684afe6955e49a19e286"
SRC_URI[sha256sum] = "74c37eb015beba34978a28ba532d0346306c7a8d8b2340790b5047bd8716546e"
