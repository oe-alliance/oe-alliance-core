DESCRIPTION = "Vhannibal E2 Settings File Quad Nordic"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.quad.nordic"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "2b39323f2fe15585c2c48196b7f4975f"
SRC_URI[sha256sum] = "2d07d3ad003e85144a68f1cc4d23f4e2e34ee1bcbc1a6e4f04fdcbce05c989a3"
