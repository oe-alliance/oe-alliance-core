DESCRIPTION = "CST Four2 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.four2.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "75a5b6fac21cac831a9d051e2139e54c"
SRC_URI[sha256sum] = "ce8fac192618c2a39e3287ab8a0c22034b56fa0b3dac03dc24d425a53c8727bd"
