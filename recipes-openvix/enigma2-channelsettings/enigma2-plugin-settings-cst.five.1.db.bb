DESCRIPTION = "CST Five.1 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.five.1.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "8293f90182dab60ecc0f263ebf9ce8b8"
SRC_URI[sha256sum] = "c1abe6f3b9880e31eed68a56d96b9961125acf37864298ef1a39714cf3b9b22a"
