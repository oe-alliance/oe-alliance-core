DESCRIPTION = "CST Trial3 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.trial3.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "082b0fb47514fec80c28ac100d4fb1b3"
SRC_URI[sha256sum] = "8e3462257cdfff8ab2943e12ed32c4d043b662d2b1576a47d4a924dd9c59cf66"
