DESCRIPTION = "CST Motor E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.motor.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "bb63c1ffe45e888e18b9ea45ab211513"
SRC_URI[sha256sum] = "a3d6cd4fdf9ab227bcc12321d113774fee4c023e1f8b30838e8b26f608665e9f"
