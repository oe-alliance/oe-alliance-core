DESCRIPTION = "Sgtflipflop E2 Settings File For 28e"
PV = "20120307"

SETTINGS_FILENAME = "sgtflipflop.28e"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "aed3bf2d23f93ddb0fcd02640d95ebd0"
SRC_URI[sha256sum] = "4a3c11ef67eb2d25a4fb2e75bde0e3ab332074e1656885336c240aa0221f1da0"
