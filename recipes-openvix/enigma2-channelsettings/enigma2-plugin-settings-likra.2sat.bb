DESCRIPTION = "Likra 2sat E2 Settings File"
PV = "20111029"

SETTINGS_FILENAME = "likra.2sat"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "5403e16eecd9333cf482042b73764249"
SRC_URI[sha256sum] = "9accc2acb67800df17fd5d4c473eaaa940c719f40549e8a9feedb30fa861499b"
