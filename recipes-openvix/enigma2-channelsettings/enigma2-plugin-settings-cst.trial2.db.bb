DESCRIPTION = "CST Trial2 E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.trial2.db"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "5d9727e23320c8bcb67ac29f77561199"
SRC_URI[sha256sum] = "689b032ffe13c14a161423f7aab48f4f1f15bd1bdc1778c4b7846ed310bc98a7"
