DESCRIPTION = "CST Dual DB DTT MI E2 Settings File"
PV = "20120304"

SETTINGS_FILENAME = "cst.dual.db.dtt.mi"

include bouquets-e2settings.inc

SRC_URI[md5sum] = "1e6d9212179aeebb8997c534bcb89231"
SRC_URI[sha256sum] = "d49b0be9f3bf70703c502ad481b91713f17a16696558ee2e7b9af7ddfc3c3946"
