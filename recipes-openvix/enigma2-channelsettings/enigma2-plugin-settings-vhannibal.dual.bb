DESCRIPTION = "Vhannibal Dual E2 Settings File"
PV = "20120303"

SETTINGS_FILENAME = "vhannibal.dual"

include bouquets-e2settings.inc
