PRINC = "1"
DEPENDS += "enigma2"

SRC_URI = "git://github.com/OpenViX/e2openplugin-OpenWebif.git;protocol=git"

S="${WORKDIR}/git"

