DESCRIPTION = "meta file for bootlogos"

require conf/license/license-gplv2.inc

DEPENDS = "\
	enigma2-plugin-bootlogo-vix \
	"

PR = "r0"
