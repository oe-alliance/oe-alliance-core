PRINC = "1"

RPROVIDES =+ " libts-1.0-0"
