PROVIDES =+ " libsysfs2"
PACKAGES =+ " libsysfs2"
