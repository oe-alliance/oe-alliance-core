FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PRINC = "1"

SRC_URI += " file://0002-fix-build-for-old-libcheader.patch"

