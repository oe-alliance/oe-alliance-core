FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PRINC = "2"

